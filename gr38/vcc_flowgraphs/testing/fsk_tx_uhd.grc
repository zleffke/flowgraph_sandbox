options:
  parameters:
    author: Zach Leffke, KJ4QLP
    description: Development transmitter or testing Lithium Radio
    generate_options: qt_gui
    id: fsk_tx_uhd
    output_language: python
    title: VCC Simple Uplink Transmitter
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,4
    label: bb_gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.75'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '24'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: samp_rate/baud
  states: {}
- name: tx_correct
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,4
    orient: Qt.Horizontal
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '-300'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,4
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '86'
    value: '0'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Baseband Gain
    const: bb_gain
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: |-
      pack bytes for 
      GMSK Mod Block
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0_2
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Expects KISS Frames on input
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    host: 0.0.0.0
    mtu: '1024'
    port: '8000'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    comment: Block tag propagation
    propagate_tags: 'False'
    single_key: '"packet_len"'
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: alpha
    comment: |-
      expects packed 
      byte stream
    samples_per_symbol: int(samps_per_symb)
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G3RUH Polynomial
      1+x^12+x^17
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim * interp
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,4,4
    legend: 'False'
    name: '"TX Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: upsample to 250k for UHD
    decim: decim
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    comment: |-
      Computes FCS, append
      Bit Stuff Frame
      Append/Prepend Flags
    postamble_bytes: '64'
    preamble_bytes: '64'
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    comment: |-
      Discard KISS FEND bytes
      Escapes Bytes as necessary
      Removes KISS CMD Byte
    control_byte: 'True'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 401.5e6
  states: {}
- name: tx_offset
  id: parameter
  parameters:
    type: eng_float
    value: 250e3
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(tx_freq+tx_correct, tx_offset)
    clock_rate: '0.0'
    comment: |-
      UHD Underflows 'U' expected
      One per uplink packet
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: 250e3
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0_2_0_1
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_scrambler_bb_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', satellites_kiss_to_pdu_0, '0']
- [blocks_socket_pdu_0_2, pdus, blocks_pdu_to_tagged_stream_1, pdus]
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_tag_gate_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0_0, '0']
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_kiss_to_pdu_0, out, satellites_hdlc_framer_0, in]
- [satellites_nrzi_encode_0, '0', blocks_pack_k_bits_bb_0, '0']
- [virtual_source_0_2_0_1, '0', digital_gmsk_mod_0, '0']

metadata:
  file_format: 1
