options:
  parameters:
    author: Zach Leffke, KJ4QLP
    category: '[VCC Hier Blocks]'
    description: Hierarchical GMSK Burst Transmitter
    generate_options: hb
    id: gmsk_tx_burst_hier2
    output_language: python
    title: GMSK TX Burst tagger
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '24'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '25'
  states: {}
- name: samp_rate_var
  id: variable
  parameters:
    value: samp_rate / interp * decim
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: samp_rate_var/baud
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: BB Gain
    type: eng_float
    value: '0.75'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: bb_gain
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: bt
  id: parameter
  parameters:
    label: BT
    type: eng_float
    value: '.5'
  states: {}
- name: delay_enable
  id: parameter
  parameters:
    label: Delay Enable
    type: intx
    value: '1'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: bt
    comment: |-
      expects packed 
      byte stream
    samples_per_symbol: int(samps_per_symb)
  states: {}
- name: foo_burst_tagger_0
  id: foo_burst_tagger
  parameters:
    comment: adds eob/sob tags
    minoutbuf: '50000'
    mult: int(samps_per_symb * 8.0 * interp / decim)
    tag_name: pmt.intern("packet_len")
  states: {}
- name: foo_packet_pad_0
  id: foo_packet_pad
  parameters:
    comment: adds tx_time tag
    debug: 'False'
    delay: bool(delay_enable)
    delay_sec: ptt_delay
    pad_front: pad_front
    pad_tail: pad_tail
  states: {}
- name: pad_front
  id: parameter
  parameters:
    label: Pad Front
    type: intx
    value: '200'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    comment: |-
      AX.25 header is not ASCII printable
      Some characters will not print properly
    label: ax25
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    comment: |-
      Expects KISS Frames on input
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    label: kiss/ax25
    type: message
  states: {}
- name: pad_tail
  id: parameter
  parameters:
    label: Pad Tail
    type: intx
    value: '200'
  states: {}
- name: pdu_utils_pack_unpack_0
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    comment: |-
      pack bytes for 
      GMSK Mod Block
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: ptt_delay
  id: parameter
  parameters:
    label: PTT Delay
    type: eng_float
    value: '0.001'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: upsample to 250k for UHD
    decim: decim
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '250000'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '64'
    preamble_bytes: '64'
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'True'
  states: {}
- name: vcc_burst_nrzi_encode_0
  id: vcc_burst_nrzi_encode
  parameters:
    comment: |-
      NRZI Differential
      Line Encoding
  states: {}
- name: vcc_burst_scramble_bb_0
  id: vcc_burst_scramble_bb
  parameters:
    comment: |-
      G3RUH Polynomial
      1+x^12+x^17
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0_2_0_1
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', pad_sink_2, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_gmsk_mod_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', satellites_kiss_to_pdu_0, '0']
- [digital_gmsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [foo_burst_tagger_0, '0', foo_packet_pad_0, '0']
- [foo_packet_pad_0, '0', blocks_multiply_const_vxx_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_1, pdus]
- [pdu_utils_pack_unpack_0, pdu_out, virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', foo_burst_tagger_0, '0']
- [satellites_hdlc_framer_0, out, vcc_burst_scramble_bb_0, in]
- [satellites_kiss_to_pdu_0, out, satellites_hdlc_framer_0, in]
- [vcc_burst_nrzi_encode_0, out, pdu_utils_pack_unpack_0, pdu_in]
- [vcc_burst_scramble_bb_0, out, vcc_burst_nrzi_encode_0, in]
- [virtual_source_0_2_0_1, '0', blocks_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
