options:
  parameters:
    generate_options: qt_gui
    id: hf_spectrum_simple_fosphor
    output_language: python
  states: {}

blocks:
- name: ahfd_ant
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 8,3,1,1
    label: AHFD Ant
    label0: N/S
    label1: E/W
    num_opts: '2'
    option0: A
    option1: B
    type: string
    value: A
  states: {}
- name: decay_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 8,2,1,1
    label0: Fast
    label1: Medium
    label2: Slow
    num_opts: '3'
    option0: '100e-6'
    option1: '65e-3'
    option2: '20e-3'
    orient: Qt.QHBoxLayout
    type: real
    value: '20e-3'
    widget: radio_buttons
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: pll_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,6,1,1
    type: real
    value: '100'
  states: {state: disabled}
- name: pll_lbw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,7,1,1
    type: real
    value: '200'
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,1,1,1
    label: FREQ
    type: real
    value: 10e6
  states: {}
- name: rx_freq_0
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,1,1,1
    label: FREQ
    type: real
    value: 10e6
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,0,1,1
    label: SAMP_RATE
    type: real
    value: 500e3
  states: {}
- name: ts_str
  id: variable
  parameters:
    value: dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ")
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 8,6,1,2
    label: Start Time [UTC]
    type: string
    value: ts_str
  states: {}
- name: y_max
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,5,1,1
    label: FREQ
    type: real
    value: '-60'
  states: {}
- name: y_max
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: y_min
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,4,1,1
    label: FREQ
    type: real
    value: '-140'
  states: {}
- name: y_min
  id: variable
  parameters:
    value: '-80'
  states: {state: disabled}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: decay_rate
    decay_rate: decay_rate
    gain: '.5'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: bypassed}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: decay_rate
    decay_rate: decay_rate
    gain: '.5'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: bypassed}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1*offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'True'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'True'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 / 65536.0
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 / 65536.0
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 0,0,8,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 0,4,8,4
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: fosphor_qt_sink_c_1
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 0,0,4,4
  states: {state: disabled}
- name: fosphor_qt_sink_c_1_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 0,4,4,4
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,4,4
    legend: 'False'
    name: '"N/S Dipole"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: y_max
    ymin: y_min
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate /decim
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,4,4,4
    legend: 'False'
    name: '"E/W Dipole"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: y_max
    ymin: y_min
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: 4,0,4,4
    int_max: '-40'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: 4,4,4,4
    int_max: '-40'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: ahfd_ant
    center_freq0: uhd.tune_request(rx_freq)
    center_freq1: uhd.tune_request(rx_freq)
    clock_rate: '0.0'
    clock_source0: gpsdo
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:AB B:AB
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_agc2_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fosphor_qt_sink_c_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', fosphor_qt_sink_c_1_0, '0']
- [blocks_multiply_xx_0, '0', fosphor_qt_sink_c_1, '0']
- [blocks_multiply_xx_0_0, '0', fosphor_qt_sink_c_1_0, '0']
- [rational_resampler_xxx_0, '0', fosphor_qt_sink_c_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', fosphor_qt_sink_c_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_1, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_1, '1', analog_agc2_xx_0_0, '0']

metadata:
  file_format: 1
