<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>kerberos_sigmf_noise_compare</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_3_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"CHAN 0"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_0</value></param>
<param><key>comment</key><value>rtl0,chan1,no_noise</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN0_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_0_0</value></param>
<param><key>comment</key><value>rtl0,chan1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN0_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_1</value></param>
<param><key>comment</key><value>rtl0,chan1,with_noise</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/with_noise/CHAN0_2021-03-26T21:12:02Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_1_0</value></param>
<param><key>comment</key><value>rtl1,chan2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN1_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_2</value></param>
<param><key>comment</key><value>rtl2,chan3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN2_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_2_0</value></param>
<param><key>comment</key><value>rtl2,chan3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN2_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_3</value></param>
<param><key>comment</key><value>rtl3,chan4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN3_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_3_0</value></param>
<param><key>comment</key><value>rtl3,chan4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/zleffke/captures/kerberos/20210326/no_noise/CHAN3_2021-03-26T21:04:01Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_2</source_block_id><sink_block_id>blocks_throttle_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_3</source_block_id><sink_block_id>blocks_throttle_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
