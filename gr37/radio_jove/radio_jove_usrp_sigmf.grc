<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radio_jove_rtlsdr</value></param>
<param><key>author</key><value>Zach Leffke, KJ4QLP</value></param>
<param><key>description</key><value>Receive Jupiter Emissions with N210 USRP on 20.1 MHz</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Radio Jove USRP Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna</value></param>
<param><key>value</key><value>"T2FD-EW"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>value</key><value>10000.0</value></param>
<param><key>gui_hint</key><value>5,4,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn</value></param>
<param><key>value</key><value>"{:s}_{:s}_{:s}".format(signal_type.upper(),antenna.upper(), ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>keep_n</value></param>
<param><key>value</key><value>2000</value></param>
<param><key>gui_hint</key><value>5,5,1,1</value></param>
<param><key>label</key><value>1inN</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>20.1e6</value></param>
<param><key>gui_hint</key><value>8,0,1,2</value></param>
<param><key>label</key><value>Freq [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%SZ")</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>keep_n</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1/avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string; import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/captures/radio_jove"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate / decim</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>4,4,1,4</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>"RSSI"</value></param>
<param><key>max</key><value>-40</value></param>
<param><key>min</key><value>-140</value></param>
<param><key>name</key><value></value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,4,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate / keep_n</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>4,0,4,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value>Zach Leffke, KJ4QLP</value></param>
<param><key>description</key><value>Radio Jove RSSI Recorder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_extra_fields</key><value>5</value></param>
<param><key>field_1_key</key><value>"misc:avg_len"</value></param>
<param><key>field_1_type</key><value>float</value></param>
<param><key>field_1_value</key><value>avg_len</value></param>
<param><key>field_10_key</key><value></value></param>
<param><key>field_10_type</key><value>string</value></param>
<param><key>field_10_value</key><value></value></param>
<param><key>field_11_key</key><value></value></param>
<param><key>field_11_type</key><value>string</value></param>
<param><key>field_11_value</key><value></value></param>
<param><key>field_12_key</key><value></value></param>
<param><key>field_12_type</key><value>string</value></param>
<param><key>field_12_value</key><value></value></param>
<param><key>field_13_key</key><value></value></param>
<param><key>field_13_type</key><value>string</value></param>
<param><key>field_13_value</key><value></value></param>
<param><key>field_14_key</key><value></value></param>
<param><key>field_14_type</key><value>string</value></param>
<param><key>field_14_value</key><value></value></param>
<param><key>field_15_key</key><value></value></param>
<param><key>field_15_type</key><value>string</value></param>
<param><key>field_15_value</key><value></value></param>
<param><key>field_16_key</key><value></value></param>
<param><key>field_16_type</key><value>string</value></param>
<param><key>field_16_value</key><value></value></param>
<param><key>field_17_key</key><value></value></param>
<param><key>field_17_type</key><value>string</value></param>
<param><key>field_17_value</key><value></value></param>
<param><key>field_18_key</key><value></value></param>
<param><key>field_18_type</key><value>string</value></param>
<param><key>field_18_value</key><value></value></param>
<param><key>field_19_key</key><value></value></param>
<param><key>field_19_type</key><value>string</value></param>
<param><key>field_19_value</key><value></value></param>
<param><key>field_2_key</key><value>"misc:analog_filter"</value></param>
<param><key>field_2_type</key><value>string</value></param>
<param><key>field_2_value</key><value>"none"</value></param>
<param><key>field_20_key</key><value></value></param>
<param><key>field_20_type</key><value>string</value></param>
<param><key>field_20_value</key><value></value></param>
<param><key>field_21_key</key><value></value></param>
<param><key>field_21_type</key><value>string</value></param>
<param><key>field_21_value</key><value></value></param>
<param><key>field_22_key</key><value></value></param>
<param><key>field_22_type</key><value>string</value></param>
<param><key>field_22_value</key><value></value></param>
<param><key>field_23_key</key><value></value></param>
<param><key>field_23_type</key><value>string</value></param>
<param><key>field_23_value</key><value></value></param>
<param><key>field_24_key</key><value></value></param>
<param><key>field_24_type</key><value>string</value></param>
<param><key>field_24_value</key><value></value></param>
<param><key>field_25_key</key><value></value></param>
<param><key>field_25_type</key><value>string</value></param>
<param><key>field_25_value</key><value></value></param>
<param><key>field_3_key</key><value>"misc:output_rate"</value></param>
<param><key>field_3_type</key><value>float</value></param>
<param><key>field_3_value</key><value>samp_rate / keep_n</value></param>
<param><key>field_4_key</key><value>"antenna:id"</value></param>
<param><key>field_4_type</key><value>string</value></param>
<param><key>field_4_value</key><value>EW_T2FD</value></param>
<param><key>field_5_key</key><value>"antenna:description"</value></param>
<param><key>field_5_type</key><value>string</value></param>
<param><key>field_5_value</key><value>"Tilted Terminated Folded Dipole"</value></param>
<param><key>field_6_key</key><value></value></param>
<param><key>field_6_type</key><value>string</value></param>
<param><key>field_6_value</key><value></value></param>
<param><key>field_7_key</key><value></value></param>
<param><key>field_7_type</key><value>string</value></param>
<param><key>field_7_value</key><value></value></param>
<param><key>field_8_key</key><value></value></param>
<param><key>field_8_type</key><value>string</value></param>
<param><key>field_8_value</key><value></value></param>
<param><key>field_9_key</key><value></value></param>
<param><key>field_9_type</key><value>string</value></param>
<param><key>field_9_value</key><value></value></param>
<param><key>filename</key><value>fp</value></param>
<param><key>hardware</key><value>N210 + LFRX + T2FD Antenna</value></param>
<param><key>type</key><value>f32</value></param>
<param><key>license</key><value>MIT</value></param>
<param><key>append</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>time_mode</key><value>gr_sigmf.sigmf_time_mode_relative</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>RADIO-JOVE</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>sd_spec0</key><value>A:AB</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
