<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>n210_record_ci16</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>ts_str</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn</value></param>
<param><key>comment</key><value>generates unique filename
each time flowgraph is run</value></param>
<param><key>value</key><value>"{:s}_{:s}_{:s}.ci16".format(signal_type, samp_str,ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp</value></param>
<param><key>comment</key><value>Creates full file path for IQ storage
Used in File Sink for file recording location</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>path</value></param>
<param><key>comment</key><value>folder to store IQ file</value></param>
<param><key>value</key><value>"/tmp"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>samp_rate/2</value></param>
<param><key>gui_hint</key><value>8,0,1,2</value></param>
<param><key>label</key><value>Frequency [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12.5e6</value></param>
<param><key>gui_hint</key><value>8,2,1,2</value></param>
<param><key>label</key><value>SAMP_RATE</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_str</value></param>
<param><key>comment</key><value>Sample Rate in 
String format</value></param>
<param><key>value</key><value>"{:3.1f}MSPS".format(samp_rate/1e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_type</value></param>
<param><key>comment</key><value>General Signal 
Description</value></param>
<param><key>value</key><value>"HF"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>comment</key><value>generates UTC timestamp string</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ")</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>comment</key><value>File: specified by the variable 'fp'
Vector length is set to 2 to match the interleaved ci16 format of the USRP Output</value></param>
<param><key>file</key><value>fp</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>comment</key><value>convert interleaved shorts 
to complex format</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>comment</key><value>1/(2^16) = 1.0/65535.0
This scales the 16bit samples back to what is 
expected for a complex32 datatype</value></param>
<param><key>const</key><value>1.0 / 65536.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>comment</key><value>python module imports</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string; import math; import numpy as np</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>* USRP Clock Rate divided by sample rate must be an even integer value to avoid halfband filtering
    - In the above example, clock rate is 100 MHz (max speed of N200/210), sample rate is 25 MSPS -&gt;  
    - 100 MHz / 25MSPS = 4 (even integer -&gt; no halfband filtering)
* USRP Output Type is Complex Integer 16 data type (yellow).
    - This allows smaller number of bits to represent the 14 bit ADC values relative to a complex32 output type (default).
    - This is an 'interleaved' format with 16bits of I, then 16 bits of Q output in 'vector' format
    - This is why the yellow is 'dark', because its a vector format.  
    - This is also why the vector input = 'yes' is selected in the Ishort to Complex block.
    - This datatype does not affect the actual tranport over the ethernet connection (see Wire Format)
* Daughtercard in the example is LFRX:
    - Subdev Spec is A:AB (comlplex sampling on receive chain A of the motherboard).
    - The LFRX has two input ports, A or B.  On the RF tab, the antenna is set to 'A' to select that SMA connector
    - The LFRX has no analog gain setting, so set to 0.
* Miscellaneous:
    - N210 used has Onboard GPSDO, selected for clock and time sources
    - Sync is set to 'listen' to the PPS input from the GPS...
        - I think this causes the flowgraph to 'pause' on startup and wait for the next PPS rising edge
        - The result of this is the first sample in the resulting file should be time aligned to the second (UTC)
        - the precision of this time alignment depends on the GPS used (I think something like 20 nanosecond accurate for firefly)</value></param>
<param><key>note</key><value>UHD Notes</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>4,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>A</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>sd_spec0</key><value>A:AB</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>otw</key><value>sc16</value></param>
</block>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
