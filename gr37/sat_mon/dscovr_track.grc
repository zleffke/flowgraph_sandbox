<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dscovr_track</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>fp_rhcp</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fft_max</value></param>
<param><key>value</key><value>-80</value></param>
<param><key>gui_hint</key><value>9,4,1,1</value></param>
<param><key>label</key><value>fft_max</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fft_min</value></param>
<param><key>value</key><value>-120</value></param>
<param><key>gui_hint</key><value>9,3,1,1</value></param>
<param><key>label</key><value>fft_min</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn_lhcp</value></param>
<param><key>value</key><value>"{:s}_LHCP_{:s}".format(signal_type.upper(), ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn_rhcp</value></param>
<param><key>value</key><value>"{:s}_RHCP_{:s}".format(signal_type.upper(), ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp_lhcp</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn_lhcp)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp_rhcp</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn_rhcp)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>2215e6</value></param>
<param><key>gui_hint</key><value>9,1,1,1</value></param>
<param><key>label</key><value>FREQ</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>9,2,1,1</value></param>
<param><key>label</key><value>GAIN</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>label</key><value>SAMP_RATE</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%SZ")</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string; import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/captures/20200329"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"RHCP"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>fft_max</value></param>
<param><key>ymin</key><value>fft_min</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,4,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"LHCP"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>fft_max</value></param>
<param><key>ymin</key><value>fft_min</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>4,0,4,4</value></param>
<param><key>int_max</key><value>fft_max</value></param>
<param><key>int_min</key><value>fft_min</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>4,4,4,4</value></param>
<param><key>int_max</key><value>fft_max</value></param>
<param><key>int_min</key><value>fft_min</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_alt</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>542</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lat</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>37.148745</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lon</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-80.578557</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value>Zach Leffke, KJ4QLP</value></param>
<param><key>description</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_extra_fields</key><value>10</value></param>
<param><key>field_1_key</key><value>"lro:pol"</value></param>
<param><key>field_1_type</key><value>string</value></param>
<param><key>field_1_value</key><value>"RHCP"</value></param>
<param><key>field_10_key</key><value>"uhd:time_src"</value></param>
<param><key>field_10_type</key><value>string</value></param>
<param><key>field_10_value</key><value>"external"</value></param>
<param><key>field_11_key</key><value></value></param>
<param><key>field_11_type</key><value>string</value></param>
<param><key>field_11_value</key><value></value></param>
<param><key>field_12_key</key><value></value></param>
<param><key>field_12_type</key><value>string</value></param>
<param><key>field_12_value</key><value></value></param>
<param><key>field_13_key</key><value></value></param>
<param><key>field_13_type</key><value>string</value></param>
<param><key>field_13_value</key><value></value></param>
<param><key>field_14_key</key><value></value></param>
<param><key>field_14_type</key><value>string</value></param>
<param><key>field_14_value</key><value></value></param>
<param><key>field_15_key</key><value></value></param>
<param><key>field_15_type</key><value>string</value></param>
<param><key>field_15_value</key><value></value></param>
<param><key>field_16_key</key><value></value></param>
<param><key>field_16_type</key><value>string</value></param>
<param><key>field_16_value</key><value></value></param>
<param><key>field_17_key</key><value></value></param>
<param><key>field_17_type</key><value>string</value></param>
<param><key>field_17_value</key><value></value></param>
<param><key>field_18_key</key><value></value></param>
<param><key>field_18_type</key><value>string</value></param>
<param><key>field_18_value</key><value></value></param>
<param><key>field_19_key</key><value></value></param>
<param><key>field_19_type</key><value>string</value></param>
<param><key>field_19_value</key><value></value></param>
<param><key>field_2_key</key><value>"uhd:rx_gain"</value></param>
<param><key>field_2_type</key><value>float</value></param>
<param><key>field_2_value</key><value>rx_gain</value></param>
<param><key>field_20_key</key><value></value></param>
<param><key>field_20_type</key><value>string</value></param>
<param><key>field_20_value</key><value></value></param>
<param><key>field_21_key</key><value></value></param>
<param><key>field_21_type</key><value>string</value></param>
<param><key>field_21_value</key><value></value></param>
<param><key>field_22_key</key><value></value></param>
<param><key>field_22_type</key><value>string</value></param>
<param><key>field_22_value</key><value></value></param>
<param><key>field_23_key</key><value></value></param>
<param><key>field_23_type</key><value>string</value></param>
<param><key>field_23_value</key><value></value></param>
<param><key>field_24_key</key><value></value></param>
<param><key>field_24_type</key><value>string</value></param>
<param><key>field_24_value</key><value></value></param>
<param><key>field_25_key</key><value></value></param>
<param><key>field_25_type</key><value>string</value></param>
<param><key>field_25_value</key><value></value></param>
<param><key>field_3_key</key><value>"uhd:channel"</value></param>
<param><key>field_3_type</key><value>string</value></param>
<param><key>field_3_value</key><value>"A"</value></param>
<param><key>field_4_key</key><value>"uhd:antenna"</value></param>
<param><key>field_4_type</key><value>string</value></param>
<param><key>field_4_value</key><value>"RX2"</value></param>
<param><key>field_5_key</key><value>"uhd:usrp_type"</value></param>
<param><key>field_5_type</key><value>string</value></param>
<param><key>field_5_value</key><value>usrp_type</value></param>
<param><key>field_6_key</key><value>"geo:rx_lat"</value></param>
<param><key>field_6_type</key><value>float</value></param>
<param><key>field_6_value</key><value>rx_lat</value></param>
<param><key>field_7_key</key><value>"geo:rx_lon"</value></param>
<param><key>field_7_type</key><value>float</value></param>
<param><key>field_7_value</key><value>rx_lon</value></param>
<param><key>field_8_key</key><value>"geo:rx_alt"</value></param>
<param><key>field_8_type</key><value>float</value></param>
<param><key>field_8_value</key><value>rx_alt</value></param>
<param><key>field_9_key</key><value>"uhd:clock_src"</value></param>
<param><key>field_9_type</key><value>string</value></param>
<param><key>field_9_value</key><value>"external"</value></param>
<param><key>filename</key><value>fp_rhcp</value></param>
<param><key>hardware</key><value>"KJ4QLP 2.3m Dish, S-Band Septum Feed, Kuhne LNA, dual Pol"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>license</key><value></value></param>
<param><key>append</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>time_mode</key><value>gr_sigmf.sigmf_time_mode_relative</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0_0</value></param>
<param><key>author</key><value>Zach Leffke, KJ4QLP</value></param>
<param><key>description</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_extra_fields</key><value>10</value></param>
<param><key>field_1_key</key><value>"lro:pol"</value></param>
<param><key>field_1_type</key><value>string</value></param>
<param><key>field_1_value</key><value>"LHCP"</value></param>
<param><key>field_10_key</key><value>"uhd:time_src"</value></param>
<param><key>field_10_type</key><value>string</value></param>
<param><key>field_10_value</key><value>"external"</value></param>
<param><key>field_11_key</key><value></value></param>
<param><key>field_11_type</key><value>string</value></param>
<param><key>field_11_value</key><value></value></param>
<param><key>field_12_key</key><value></value></param>
<param><key>field_12_type</key><value>string</value></param>
<param><key>field_12_value</key><value></value></param>
<param><key>field_13_key</key><value></value></param>
<param><key>field_13_type</key><value>string</value></param>
<param><key>field_13_value</key><value></value></param>
<param><key>field_14_key</key><value></value></param>
<param><key>field_14_type</key><value>string</value></param>
<param><key>field_14_value</key><value></value></param>
<param><key>field_15_key</key><value></value></param>
<param><key>field_15_type</key><value>string</value></param>
<param><key>field_15_value</key><value></value></param>
<param><key>field_16_key</key><value></value></param>
<param><key>field_16_type</key><value>string</value></param>
<param><key>field_16_value</key><value></value></param>
<param><key>field_17_key</key><value></value></param>
<param><key>field_17_type</key><value>string</value></param>
<param><key>field_17_value</key><value></value></param>
<param><key>field_18_key</key><value></value></param>
<param><key>field_18_type</key><value>string</value></param>
<param><key>field_18_value</key><value></value></param>
<param><key>field_19_key</key><value></value></param>
<param><key>field_19_type</key><value>string</value></param>
<param><key>field_19_value</key><value></value></param>
<param><key>field_2_key</key><value>"uhd:rx_gain"</value></param>
<param><key>field_2_type</key><value>float</value></param>
<param><key>field_2_value</key><value>rx_gain</value></param>
<param><key>field_20_key</key><value></value></param>
<param><key>field_20_type</key><value>string</value></param>
<param><key>field_20_value</key><value></value></param>
<param><key>field_21_key</key><value></value></param>
<param><key>field_21_type</key><value>string</value></param>
<param><key>field_21_value</key><value></value></param>
<param><key>field_22_key</key><value></value></param>
<param><key>field_22_type</key><value>string</value></param>
<param><key>field_22_value</key><value></value></param>
<param><key>field_23_key</key><value></value></param>
<param><key>field_23_type</key><value>string</value></param>
<param><key>field_23_value</key><value></value></param>
<param><key>field_24_key</key><value></value></param>
<param><key>field_24_type</key><value>string</value></param>
<param><key>field_24_value</key><value></value></param>
<param><key>field_25_key</key><value></value></param>
<param><key>field_25_type</key><value>string</value></param>
<param><key>field_25_value</key><value></value></param>
<param><key>field_3_key</key><value>"uhd:channel"</value></param>
<param><key>field_3_type</key><value>string</value></param>
<param><key>field_3_value</key><value>"B"</value></param>
<param><key>field_4_key</key><value>"uhd:antenna"</value></param>
<param><key>field_4_type</key><value>string</value></param>
<param><key>field_4_value</key><value>"RX2"</value></param>
<param><key>field_5_key</key><value>"uhd:usrp_type"</value></param>
<param><key>field_5_type</key><value>string</value></param>
<param><key>field_5_value</key><value>usrp_type</value></param>
<param><key>field_6_key</key><value>"geo:rx_lat"</value></param>
<param><key>field_6_type</key><value>float</value></param>
<param><key>field_6_value</key><value>rx_lat</value></param>
<param><key>field_7_key</key><value>"geo:rx_lon"</value></param>
<param><key>field_7_type</key><value>float</value></param>
<param><key>field_7_value</key><value>rx_lon</value></param>
<param><key>field_8_key</key><value>"geo:rx_alt"</value></param>
<param><key>field_8_type</key><value>float</value></param>
<param><key>field_8_value</key><value>rx_alt</value></param>
<param><key>field_9_key</key><value>"uhd:clock_src"</value></param>
<param><key>field_9_type</key><value>string</value></param>
<param><key>field_9_value</key><value>"external"</value></param>
<param><key>filename</key><value>fp_lhcp</value></param>
<param><key>hardware</key><value>"KJ4QLP 2.3m Dish, S-Band Septum Feed, Kuhne LNA, dual Pol"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>license</key><value></value></param>
<param><key>append</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>time_mode</key><value>gr_sigmf.sigmf_time_mode_relative</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>DSCOVR</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>uhd.tune_request(rx_freq, samp_rate/2)</value></param>
<param><key>dc_offs_enb1</key><value>True</value></param>
<param><key>iq_imbal_enb1</key><value>True</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=30CF9D2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>B210</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>rhcp_stream</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>lhcp_stream</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>rhcp_stream</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>lhcp_stream</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>sigmf_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
