<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dtv_sigmf</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate, samp_rate/2, 50000, firdes.WIN_FLATTOP, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn</value></param>
<param><key>value</key><value>"{:s}_{:s}".format(signal_name, ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp</value></param>
<param><key>value</key><value>"/captures/dtv/{:s}".format(fn)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>602.31e6</value></param>
<param><key>gui_hint</key><value>9,2,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>162e6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>45</value></param>
<param><key>gui_hint</key><value>8,0,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
<param><key>gui_hint</key><value>9,4,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ")</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>8,2,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>tune</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zleffke/sandbox/ais/ais_20161216_250k_2.32fc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate*4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cyborg_version</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>v0.1.0</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_order</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_scheme</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ATSC_8VSB</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,2,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>"DTV"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,0,2,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Channel"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ant_model</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Decotec Tape Measure Discone</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_db_ser</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>na</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_db_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>na</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ser_tag</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>F50030</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ser_uhd</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>F50030</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>B210</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value></value></param>
<param><key>description</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_extra_fields</key><value>13</value></param>
<param><key>field_1_key</key><value>"usrp:rx_type"</value></param>
<param><key>field_1_type</key><value>string</value></param>
<param><key>field_1_value</key><value>rx_type</value></param>
<param><key>field_10_key</key><value>"usrp:version"</value></param>
<param><key>field_10_type</key><value>string</value></param>
<param><key>field_10_value</key><value>v0.1.0</value></param>
<param><key>field_11_key</key><value>"usrp:rx_rf_gain"</value></param>
<param><key>field_11_type</key><value>float</value></param>
<param><key>field_11_value</key><value>rx_gain</value></param>
<param><key>field_12_key</key><value>"usrp:rx_freq"</value></param>
<param><key>field_12_type</key><value>float</value></param>
<param><key>field_12_value</key><value>rx_freq</value></param>
<param><key>field_13_key</key><value>"usrp:rx_ant_model"</value></param>
<param><key>field_13_type</key><value>string</value></param>
<param><key>field_13_value</key><value>rx_ant_model</value></param>
<param><key>field_14_key</key><value></value></param>
<param><key>field_14_type</key><value>string</value></param>
<param><key>field_14_value</key><value></value></param>
<param><key>field_15_key</key><value></value></param>
<param><key>field_15_type</key><value>string</value></param>
<param><key>field_15_value</key><value></value></param>
<param><key>field_16_key</key><value></value></param>
<param><key>field_16_type</key><value>string</value></param>
<param><key>field_16_value</key><value></value></param>
<param><key>field_17_key</key><value></value></param>
<param><key>field_17_type</key><value>string</value></param>
<param><key>field_17_value</key><value></value></param>
<param><key>field_18_key</key><value></value></param>
<param><key>field_18_type</key><value>string</value></param>
<param><key>field_18_value</key><value></value></param>
<param><key>field_19_key</key><value></value></param>
<param><key>field_19_type</key><value>string</value></param>
<param><key>field_19_value</key><value></value></param>
<param><key>field_2_key</key><value>"usrp:rx_ser_uhd"</value></param>
<param><key>field_2_type</key><value>string</value></param>
<param><key>field_2_value</key><value>rx_ser_uhd</value></param>
<param><key>field_20_key</key><value></value></param>
<param><key>field_20_type</key><value>string</value></param>
<param><key>field_20_value</key><value></value></param>
<param><key>field_21_key</key><value></value></param>
<param><key>field_21_type</key><value>string</value></param>
<param><key>field_21_value</key><value></value></param>
<param><key>field_22_key</key><value></value></param>
<param><key>field_22_type</key><value>string</value></param>
<param><key>field_22_value</key><value></value></param>
<param><key>field_23_key</key><value></value></param>
<param><key>field_23_type</key><value>string</value></param>
<param><key>field_23_value</key><value></value></param>
<param><key>field_24_key</key><value></value></param>
<param><key>field_24_type</key><value>string</value></param>
<param><key>field_24_value</key><value></value></param>
<param><key>field_25_key</key><value></value></param>
<param><key>field_25_type</key><value>string</value></param>
<param><key>field_25_value</key><value></value></param>
<param><key>field_3_key</key><value>"usrp:rx_ser_tag"</value></param>
<param><key>field_3_type</key><value>string</value></param>
<param><key>field_3_value</key><value>rx_ser_tag</value></param>
<param><key>field_4_key</key><value>"usrp:rx_db_type"</value></param>
<param><key>field_4_type</key><value>string</value></param>
<param><key>field_4_value</key><value>rx_db_type</value></param>
<param><key>field_5_key</key><value>"usrp:rx_db_ser"</value></param>
<param><key>field_5_type</key><value>string</value></param>
<param><key>field_5_value</key><value>rx_db_ser</value></param>
<param><key>field_6_key</key><value>"modulation:scheme"</value></param>
<param><key>field_6_type</key><value>string</value></param>
<param><key>field_6_value</key><value>mod_scheme</value></param>
<param><key>field_7_key</key><value>"modulation:order"</value></param>
<param><key>field_7_type</key><value>int</value></param>
<param><key>field_7_value</key><value>mod_order</value></param>
<param><key>field_8_key</key><value>"cyborg:symbol_rate"</value></param>
<param><key>field_8_type</key><value>float</value></param>
<param><key>field_8_value</key><value>symbol_rate</value></param>
<param><key>field_9_key</key><value>"cyborg:version"</value></param>
<param><key>field_9_type</key><value>string</value></param>
<param><key>field_9_value</key><value>cyborg_version</value></param>
<param><key>filename</key><value>fp</value></param>
<param><key>hardware</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>license</key><value></value></param>
<param><key>append</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>time_mode</key><value>sigmf.sigmf_time_mode_absolute</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>DTV</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10.76e6</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
