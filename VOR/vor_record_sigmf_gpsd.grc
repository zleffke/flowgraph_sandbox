<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vor_record_sigmf</value></param>
<param><key>author</key><value>Zach Leffke</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Generic SigMF Recorder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>vor_record_sigmf</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fine</value></param>
<param><key>value</key><value>-1.9e3</value></param>
<param><key>gui_hint</key><value>1,6,1,2</value></param>
<param><key>label</key><value>Fine [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn</value></param>
<param><key>value</key><value>"{:s}_{:s}".format(signal_type.upper(), ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp_0</value></param>
<param><key>value</key><value>"{:s}/{:s}.gps".format(path, fn)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>116.8e6</value></param>
<param><key>gui_hint</key><value>1,4,1,2</value></param>
<param><key>label</key><value>Freq [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>gui_hint</key><value>2,4,1,2</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
<param><key>gui_hint</key><value>0,4,1,4</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%SZ")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ")</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>serial=314FC3C</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>addr=192.168.10.4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Diamond X-50, 50ft LMR-400UF</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>60e6</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,8,4</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>gps_nmea_gpsd</key>
<param><key>id</key><value>gps_nmea_gpsd_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>protocol</key><value>'gpsd'</value></param>
<param><key>port</key><value>2947</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string; import math; import pmt</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>morse_id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>PSK | .--. ... -.-</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_format</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Complex Float32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/captures/20191218"</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>gui_hint</key><value>7,4,1,2</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate / 5</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,4,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,4,2,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_alt</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>655</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lat</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>37.206862</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lon</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-80.419096</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value>Zach Leffke</value></param>
<param><key>description</key><value>SigMF Receiver w/ gr-fosphor display</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_extra_fields</key><value>15</value></param>
<param><key>field_1_key</key><value>"uhd:rx_gain"</value></param>
<param><key>field_1_type</key><value>float</value></param>
<param><key>field_1_value</key><value>rx_gain</value></param>
<param><key>field_10_key</key><value>"geo:rx_alt"</value></param>
<param><key>field_10_type</key><value>float</value></param>
<param><key>field_10_value</key><value>rx_alt</value></param>
<param><key>field_11_key</key><value>"geo:tx_lat"</value></param>
<param><key>field_11_type</key><value>float</value></param>
<param><key>field_11_value</key><value>tx_lat</value></param>
<param><key>field_12_key</key><value>"geo:tx_lon"</value></param>
<param><key>field_12_type</key><value>float</value></param>
<param><key>field_12_value</key><value>tx_lon</value></param>
<param><key>field_13_key</key><value>"geo:tx_alt"</value></param>
<param><key>field_13_type</key><value>float</value></param>
<param><key>field_13_value</key><value>tx_alt</value></param>
<param><key>field_14_key</key><value>"vor:morse_id"</value></param>
<param><key>field_14_type</key><value>string</value></param>
<param><key>field_14_value</key><value>morse_id</value></param>
<param><key>field_15_key</key><value>"uhd:fine_adjust"</value></param>
<param><key>field_15_type</key><value>float</value></param>
<param><key>field_15_value</key><value>fine</value></param>
<param><key>field_16_key</key><value></value></param>
<param><key>field_16_type</key><value>string</value></param>
<param><key>field_16_value</key><value></value></param>
<param><key>field_17_key</key><value></value></param>
<param><key>field_17_type</key><value>string</value></param>
<param><key>field_17_value</key><value></value></param>
<param><key>field_18_key</key><value></value></param>
<param><key>field_18_type</key><value>string</value></param>
<param><key>field_18_value</key><value></value></param>
<param><key>field_19_key</key><value></value></param>
<param><key>field_19_type</key><value>string</value></param>
<param><key>field_19_value</key><value></value></param>
<param><key>field_2_key</key><value>"misc:signal_type"</value></param>
<param><key>field_2_type</key><value>string</value></param>
<param><key>field_2_value</key><value>signal_type</value></param>
<param><key>field_20_key</key><value></value></param>
<param><key>field_20_type</key><value>string</value></param>
<param><key>field_20_value</key><value></value></param>
<param><key>field_21_key</key><value></value></param>
<param><key>field_21_type</key><value>string</value></param>
<param><key>field_21_value</key><value></value></param>
<param><key>field_22_key</key><value></value></param>
<param><key>field_22_type</key><value>string</value></param>
<param><key>field_22_value</key><value></value></param>
<param><key>field_23_key</key><value></value></param>
<param><key>field_23_type</key><value>string</value></param>
<param><key>field_23_value</key><value></value></param>
<param><key>field_24_key</key><value></value></param>
<param><key>field_24_type</key><value>string</value></param>
<param><key>field_24_value</key><value></value></param>
<param><key>field_25_key</key><value></value></param>
<param><key>field_25_type</key><value>string</value></param>
<param><key>field_25_value</key><value></value></param>
<param><key>field_3_key</key><value>"misc:antenna_type"</value></param>
<param><key>field_3_type</key><value>string</value></param>
<param><key>field_3_value</key><value>antenna_type</value></param>
<param><key>field_4_key</key><value>"uhd:usrp_type"</value></param>
<param><key>field_4_type</key><value>string</value></param>
<param><key>field_4_value</key><value>usrp_type</value></param>
<param><key>field_5_key</key><value>"uhd:wire_format"</value></param>
<param><key>field_5_type</key><value>string</value></param>
<param><key>field_5_value</key><value>wire_format</value></param>
<param><key>field_6_key</key><value>"uhd:output_format"</value></param>
<param><key>field_6_type</key><value>string</value></param>
<param><key>field_6_value</key><value>output_format</value></param>
<param><key>field_7_key</key><value>"uhd:clock_rate"</value></param>
<param><key>field_7_type</key><value>float</value></param>
<param><key>field_7_value</key><value>clock_rate</value></param>
<param><key>field_8_key</key><value>"geo:rx_lat"</value></param>
<param><key>field_8_type</key><value>float</value></param>
<param><key>field_8_value</key><value>rx_lat</value></param>
<param><key>field_9_key</key><value>"geo:rx_lon"</value></param>
<param><key>field_9_type</key><value>float</value></param>
<param><key>field_9_value</key><value>rx_lon</value></param>
<param><key>filename</key><value>fp</value></param>
<param><key>hardware</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>license</key><value></value></param>
<param><key>append</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>time_mode</key><value>gr_sigmf.sigmf_time_mode_relative</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>VOR</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_alt</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>340</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_lat</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>37.087692</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_lon</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-80.712887</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq+fine, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>60e6</value></param>
<param><key>dev_addr</key><value>addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>B210</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_type</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>N210_LFRX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wire_format</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Automatic</value></param>
</block>
<connection><source_block_id>gps_nmea_gpsd_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>gps_msg</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gps_nmea_gpsd_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
