<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_tx_es</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>.75</value></param>
<param><key>gui_hint</key><value>5,0,1,4</value></param>
<param><key>label</key><value>bb_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mult</value></param>
<param><key>value</key><value>(samp_rate)/2/3.141593</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>gui_hint</key><value>6,0,1,4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>int(samp_rate/baud)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>thresh</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>7,0,1,4</value></param>
<param><key>label</key><value>thresh</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.5</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_correct</value></param>
<param><key>value</key><value>2000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>12,8,1,4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>10,8,1,4</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>86</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-3</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>noise_amp</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>gain</key><value>(samp_rate/decim)/(2*math.pi*fsk_dev/8.0)</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>bb_gain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
<param><key>minoutbuf</key><value>16384</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>256+7+7+2+2</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_2</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>mtu</key><value>1024</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>16384</value></param>
<param><key>packet_len</key><value>4096*3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
<param><key>single_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
<param><key>single_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
<param><key>single_key</key><value>"es::event_buffer"</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.25</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samps_per_symb*(1+0.0)/decim</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>alpha</value></param>
<param><key>samples_per_symbol</key><value>samps_per_symb</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x0</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>lookback</key><value>100</value></param>
<param><key>guard</key><value>25000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>thresh</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fsk_dev</value></param>
<param><key>label</key><value>FSK Deviation</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>300</value></param>
</block>
<block>
<key>kiss_hdlc_framer</key>
<param><key>id</key><value>kiss_hdlc_framer_0</value></param>
<param><key>postamble_bytes</key><value>16</value></param>
<param><key>preamble_bytes</key><value>64</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>lpf_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>lpf_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lpf_cutoff</value></param>
<param><key>label</key><value>LPF Cutoff</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>12.5e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lpf_trans</value></param>
<param><key>label</key><value>LPF Trans Width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>pyqt_cpsd_plot</key>
<param><key>id</key><value>pyqt_cpsd_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_text_input</key>
<param><key>id</key><value>pyqt_text_input_0</value></param>
<param><key>gui_hint</key><value>4,0,1,4</value></param>
</block>
<block>
<key>pyqt_text_output</key>
<param><key>id</key><value>pyqt_text_output_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"TX Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1_0</value></param>
<param><key>bw</key><value>samp_rate/decim</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,4,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"RX Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>4,4,3,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>436e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_offset</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(tx_freq+tx_correct, tx_offset)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tx_symbols</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tx_symbols</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0_0</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0_1</value></param>
<param><key>stream_id</key><value>tx_symbols</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_tag_gate_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>blocks_tag_gate_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>kiss_hdlc_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_2</source_block_id><sink_block_id>kiss_hdlc_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>pdus</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_cpsd_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>pyqt_text_output_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>kiss_hdlc_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pyqt_text_input_0</source_block_id><sink_block_id>kiss_hdlc_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
