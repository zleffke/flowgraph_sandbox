<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>inmarsat_cband_x310</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>fn</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>chan_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>9,4,1,2</value></param>
<param><key>label</key><value>chan_offset</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn</value></param>
<param><key>value</key><value>"{:s}_{:s}_{:s}_{:s}M.fc32".format(sat_name, radio_id, ts_str, str(int(samp_rate/1e6)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"/home/zleffke/captures/{:s}".format(fn)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs_lo</value></param>
<param><key>value</key><value>5150e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_freq</value></param>
<param><key>value</key><value>hs_lo-rf_freq</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>if_freq_lbl</value></param>
<param><key>value</key><value>if_freq</value></param>
<param><key>gui_hint</key><value>10,1,1,1</value></param>
<param><key>label</key><value>IF [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>9,2,1,1</value></param>
<param><key>label</key><value>offset</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rf_freq</value></param>
<param><key>value</key><value>3625e6</value></param>
<param><key>gui_hint</key><value>10,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>9,3,1,1</value></param>
<param><key>label</key><value>GAIN</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>50e6</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>label</key><value>SAMP_RATE</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y%m%d_%H%M%S.%f" )+'_UTC'</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-1*offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-1*(decim*chan_offset)</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>rf_freq</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>rf_freq + offset</value></param>
<param><key>gui_hint</key><value>0,0,8,4</value></param>
<param><key>freq_span</key><value>samp_rate/decim</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0_0</value></param>
<param><key>freq_center</key><value>rf_freq + offset + chan_offset</value></param>
<param><key>gui_hint</key><value>0,4,8,4</value></param>
<param><key>freq_span</key><value>samp_rate/decim/decim2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate/decim</value></param>
<param><key>fc</key><value>rf_freq + offset</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Transponder"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate/decim/decim2</value></param>
<param><key>fc</key><value>rf_freq + offset +chan_offset</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,4,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Channel"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>4,0,4,4</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>int_min</key><value>-90</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Transponder"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim/decim2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>4,4,4,4</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>int_min</key><value>-90</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Channel"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>30CF9D2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>decim2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sat_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>4F3</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>if_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>satellite</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>xpondr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>satellite</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>xpondr</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
