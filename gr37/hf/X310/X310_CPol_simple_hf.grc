options:
  parameters:
    generate_options: qt_gui
    id: x310_cpol_simple_hf
    output_language: python
    title: title_str
  states: {}

blocks:
- name: c_ms
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, 2.5,0.1,0.02,firdes.WIN_HAMMING)
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: usrp_ddc_freq - offset_tune
  states: {}
- name: lo_freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@3:4,4,1,2
    label: LO Freq [Hz]
    type: string
    value: '"{:9f}".format(lo_freq)'
  states: {state: disabled}
- name: lpf2_cut
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:8,2,1,1
    label: LPF Cutoff
    type: real
    value: 1e3
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,2,1,1
    label: LPF Cutoff
    type: real
    value: samp_rate/2.0
  states: {}
- name: offset_tune
  id: variable
  parameters:
    value: '-10000'
  states: {}
- name: phase_rad
  id: variable
  parameters:
    value: phase_shift_deg *math.pi / 180.0
  states: {}
- name: phase_shift
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:8,0,1,1
    label: Phase Shift [deg]
    type: real
    value: '90'
  states: {state: disabled}
- name: phase_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: main_tab@2:8,0,1,2
    label: Phase Shift [deg]
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '359'
    value: '90'
  states: {state: disabled}
- name: phase_shift_deg
  id: variable
  parameters:
    value: '90'
  states: {}
- name: pll_avg
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@4:5,4,1,2
    type: real
    value: '100000'
  states: {}
- name: pll_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@4:4,4,1,2
    type: real
    value: '100'
  states: {}
- name: pll_lbw
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@4:4,6,1,2
    type: real
    value: '100'
  states: {}
- name: pll_lpf_cut
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@3:8,3,1,1
    type: real
    value: '10'
  states: {}
- name: pol_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: main_tab@2:8,0,1,1
    label: Polarization Selection
    label0: NS
    label1: EW
    label2: RHCP
    label3: LHCP
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,1,1,1
    label: FREQ
    type: real
    value: 10e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 8,0,1,1
    label: SAMP_RATE
    type: real
    value: 250e3
  states: {}
- name: selection
  id: variable
  parameters:
    value: ((1,0,0,0),(0,1,0,0),(0,0,1,0),(0,0,0,1))
  states: {}
- name: title_str
  id: variable
  parameters:
    value: '"Dual Polarization Phase Correlation, Start Time [UTC]: {:s}".format(ts_str)'
  states: {}
- name: ts_str
  id: variable
  parameters:
    value: dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ")
  states: {}
- name: usrp_clk_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: usrp_ddc_freq
  id: variable
  parameters:
    value: np.round(usrp_tune_freq/usrp_clk_rate* 2**32)/2**32*usrp_clk_rate
  states: {}
- name: usrp_tune_freq
  id: variable
  parameters:
    value: rx_freq+ offset_tune
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: math.pi/pll_freq
    min_freq: '-math.pi/pll_freq'
    w: math.pi/pll_lbw
  states: {}
- name: analog_pll_freqdet_cf_0_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: math.pi/pll_freq
    min_freq: '-math.pi/pll_freq'
    w: math.pi/pll_lbw
  states: {}
- name: analog_pll_freqdet_cf_0_0_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: math.pi/pll_freq
    min_freq: '-math.pi/pll_freq'
    w: math.pi/pll_lbw
  states: {}
- name: analog_pll_freqdet_cf_0_1
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: math.pi/pll_freq
    min_freq: '-math.pi/pll_freq'
    w: math.pi/pll_lbw
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(pll_avg)
    max_iter: '4000'
    scale: 1.0/pll_avg
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(pll_avg)
    max_iter: '4000'
    scale: 1.0/pll_avg
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: int(pll_avg)
    max_iter: '4000'
    scale: 1.0/pll_avg
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: int(pll_avg)
    max_iter: '4000'
    scale: 1.0/pll_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: phase_align
    const: complex(math.cos(phase_rad),math.sin(phase_rad))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: phase_align
    const: complex(math.cos(phase_rad),math.sin(phase_rad))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/decim/decim2/(2*math.pi)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/decim/decim2/(2*math.pi)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/decim/decim2/(2*math.pi)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/decim/decim2/(2*math.pi)
    type: float
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: (selection[pol_select],)
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_sub_xx_1_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_freq - usrp_ddc_freq
    decim: '1'
    samp_rate: samp_rate / decim
    taps: filter_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_freq - usrp_ddc_freq
    decim: '1'
    samp_rate: samp_rate / decim
    taps: filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math; import numpy as np
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: pll_lpf_cut
    decim: decim2
    gain: '1'
    samp_rate: samp_rate / decim
    type: fir_filter_ccf
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: pll_lpf_cut
    decim: decim2
    gain: '1'
    samp_rate: samp_rate / decim
    type: fir_filter_ccf
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: pll_lpf_cut
    decim: decim2
    gain: '1'
    samp_rate: samp_rate / decim
    type: fir_filter_ccf
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf2_cut
    decim: decim2
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_2
  id: low_pass_filter
  parameters:
    cutoff_freq: pll_lpf_cut
    decim: decim2
    gain: '1'
    samp_rate: samp_rate / decim
    type: fir_filter_ccf
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,8,8
    label0: NS_EW
    label1: RHCP_LHCP
    label2: CPol_FFT
    label3: CPol_Spectrogram
    label4: PLL
    label5: Phase Compare 2
    num_tabs: '6'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:0,0,4,4
    legend: 'False'
    name: '"North/South"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:0,4,4,4
    legend: 'False'
    name: '"East/West"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,4,4,4
    legend: 'False'
    name: '"LHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@3:0,3,1,1
    legend: 'False'
    name: '"LHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@3:0,1,1,1
    legend: 'False'
    name: '"East/West"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,0,4,4
    legend: 'False'
    name: '"RHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@3:0,2,1,1
    legend: 'False'
    name: '"RHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@3:0,0,1,1
    legend: 'False'
    name: '"North/South"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim / decim2
    fc: rx_freq*0
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@2:0,0,4,4
    name: ''
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-70'
    ymin: '-160'
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim / decim2
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: main_tab@4:0,0,2,4
    label1: RHCP
    label2: LHCP
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim / decim2
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: main_tab@5:0,0,2,4
    label1: RHCP
    label2: LHCP
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_histogram_sink_x_1_1
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '1000'
    gui_hint: main_tab@4:2,0,2,4
    name: '"Freq Offset [Hz]"'
    size: '100'
    type: float
    update_time: '0.010'
    xmax: '4'
    xmin: '-4'
  states: {}
- name: qtgui_histogram_sink_x_1_1_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '1000'
    gui_hint: main_tab@4:4,0,2,4
    label1: R
    label2: L
    label3: NS
    label4: EW
    name: '"Freq [Hz]"'
    nconnections: '4'
    size: '100'
    type: float
    update_time: '0.010'
    xmax: '10'
    xmin: '-10'
  states: {}
- name: qtgui_histogram_sink_x_1_1_0_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '1000'
    gui_hint: main_tab@5:4,0,2,4
    label1: NS
    label2: EW
    name: '"Freq [Hz]"'
    nconnections: '2'
    size: '100'
    type: float
    update_time: '0.010'
    xmax: '10'
    xmin: '-10'
  states: {}
- name: qtgui_histogram_sink_x_1_1_1
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '1000'
    gui_hint: main_tab@5:2,0,2,4
    name: '"Freq Offset [Hz]"'
    size: '100'
    type: float
    update_time: '0.010'
    xmax: '4'
    xmin: '-4'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: main_tab@4:4,6,1,2
    label1: RHCP
    label2: LHCP
    label3: Delta
    max: '1000'
    min: '-1000'
    name: '"PLL Freq Offset [Hz]"'
    nconnections: '3'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: main_tab@4:4,6,1,2
    label1: RHCP
    label2: LHCP
    label3: Delta
    max: '1000'
    min: '-1000'
    name: '"PLL Freq Offset [Hz]"'
    nconnections: '3'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@4:0,4,2,4
    label1: RHCP
    label2: LHCP
    nconnections: '2'
    size: '1024'
    srate: samp_rate / decim / decim2
    type: float
    update_time: '0.010'
    ylabel: PLL Freq Offset [Hz]
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@4:2,4,2,4
    label1: RHCP
    size: '1024'
    srate: samp_rate / decim / decim2
    type: float
    update_time: '0.010'
    ylabel: Freq Delta [Hz]
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@5:2,4,2,4
    label1: NSEW
    size: '1024'
    srate: samp_rate / decim / decim2
    type: float
    update_time: '0.010'
    ylabel: Freq Delta [Hz]
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: main_tab@5:0,4,2,4
    label1: NS
    label2: EW
    nconnections: '2'
    size: '1024'
    srate: samp_rate / decim / decim2
    type: float
    update_time: '0.010'
    ylabel: PLL Freq Offset [Hz]
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@0:4,0,4,4
    int_max: '-80'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@0:4,4,4,4
    int_max: '-80'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:4,4,4,4
    int_max: '-80'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@3:1,3,1,1
    int_max: '-80'
    name: '"LHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@3:1,1,1,1
    int_max: '-80'
    name: '"E/W"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@1:4,0,4,4
    int_max: '-80'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@3:1,2,1,1
    int_max: '-80'
    name: '"RHCP"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@3:1,0,1,1
    int_max: '-80'
    name: '"N/S"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_2_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim / decim2
    fc: rx_freq
    fftsize: '2048'
    gui_hint: main_tab@2:4,0,4,4
    int_max: '-70'
    int_min: '-160'
    name: ''
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    center_freq0: uhd.tune_request(usrp_tune_freq)
    center_freq1: uhd.tune_request(usrp_tune_freq)
    clock_rate: 200e6
    clock_source0: gpsdo
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:AB B:AB
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rhcp_filt
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: ns_ant_90
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: ns_ant
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_source_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_source_1_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: ew_ant
  states: {}

connections:
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_agc2_xx_0, '0', virtual_sink_2, '0']
- [analog_agc2_xx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_agc2_xx_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [analog_agc2_xx_1, '0', virtual_sink_3, '0']
- [analog_pll_freqdet_cf_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [analog_pll_freqdet_cf_0_0, '0', blocks_moving_average_xx_1, '0']
- [analog_pll_freqdet_cf_0_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [analog_pll_freqdet_cf_0_1, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [blocks_add_xx_0, '0', virtual_sink_2_0_0_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_2_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_multiply_const_vxx_1_0_1, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_multiply_const_vxx_1_0_1_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_2_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_sub_xx_1_1, '1']
- [blocks_multiply_const_vxx_1_0_1, '0', qtgui_histogram_sink_x_1_1_0, '0']
- [blocks_multiply_const_vxx_1_0_1, '0', qtgui_number_sink_0_0, '1']
- [blocks_multiply_const_vxx_1_0_1, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_multiply_const_vxx_1_0_1_0, '0', blocks_sub_xx_1_1_0, '1']
- [blocks_multiply_const_vxx_1_0_1_0, '0', qtgui_histogram_sink_x_1_1_0, '3']
- [blocks_multiply_const_vxx_1_0_1_0, '0', qtgui_histogram_sink_x_1_1_0_0, '0']
- [blocks_multiply_const_vxx_1_0_1_0, '0', qtgui_number_sink_0_0_0, '1']
- [blocks_multiply_const_vxx_1_0_1_0, '0', qtgui_time_sink_x_0_1_1, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_sub_xx_1_1, '0']
- [blocks_multiply_const_vxx_1_1, '0', qtgui_histogram_sink_x_1_1_0, '1']
- [blocks_multiply_const_vxx_1_1, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', blocks_sub_xx_1_1_0, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', qtgui_histogram_sink_x_1_1_0, '2']
- [blocks_multiply_const_vxx_1_1_0, '0', qtgui_histogram_sink_x_1_1_0_0, '1']
- [blocks_multiply_const_vxx_1_1_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', qtgui_time_sink_x_0_1_1, '0']
- [blocks_multiply_matrix_xx_0, '0', low_pass_filter_0_1_1_0, '0']
- [blocks_sub_xx_1_1, '0', qtgui_histogram_sink_x_1_1, '0']
- [blocks_sub_xx_1_1, '0', qtgui_number_sink_0_0, '2']
- [blocks_sub_xx_1_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_sub_xx_1_1_0, '0', qtgui_histogram_sink_x_1_1_1, '0']
- [blocks_sub_xx_1_1_0, '0', qtgui_number_sink_0_0_0, '2']
- [blocks_sub_xx_1_1_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_agc2_xx_1, '0']
- [low_pass_filter_0_1, '0', analog_pll_freqdet_cf_0, '0']
- [low_pass_filter_0_1, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_0_1, '0', virtual_sink_1, '0']
- [low_pass_filter_0_1_0, '0', analog_pll_freqdet_cf_0_0, '0']
- [low_pass_filter_0_1_0, '0', qtgui_freq_sink_x_1_0, '1']
- [low_pass_filter_0_1_0_0, '0', analog_pll_freqdet_cf_0_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', qtgui_freq_sink_x_1_0_0, '1']
- [low_pass_filter_0_1_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [low_pass_filter_0_1_1_0, '0', qtgui_freq_sink_x_0_2_0, '0']
- [low_pass_filter_0_1_1_0, '0', qtgui_waterfall_sink_x_0_2_0, '0']
- [low_pass_filter_0_1_2, '0', analog_pll_freqdet_cf_0_1, '0']
- [low_pass_filter_0_1_2, '0', qtgui_freq_sink_x_1_0_0, '0']
- [low_pass_filter_0_2, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_1, '0', low_pass_filter_0_2, '0']
- [uhd_usrp_source_1, '1', low_pass_filter_0_1_1, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_matrix_xx_0, '0']
- [virtual_source_0_0_0, '0', qtgui_freq_sink_x_0_2, '0']
- [virtual_source_0_0_0, '0', qtgui_waterfall_sink_x_0_2, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_matrix_xx_0, '2']
- [virtual_source_0_0_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_waterfall_sink_x_0_1_0, '0']
- [virtual_source_0_0_0_0_0, '0', low_pass_filter_0_1, '0']
- [virtual_source_0_0_0_0_0_0, '0', low_pass_filter_0_1_2, '0']
- [virtual_source_1_0, '0', blocks_add_xx_0, '1']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [virtual_source_1_0_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [virtual_source_1_0_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [virtual_source_1_0_0_0, '0', blocks_multiply_matrix_xx_0, '3']
- [virtual_source_1_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [virtual_source_1_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [virtual_source_1_0_1_0, '0', low_pass_filter_0_1_0, '0']
- [virtual_source_1_0_1_0_0, '0', low_pass_filter_0_1_0_0, '0']

metadata:
  file_format: 1
