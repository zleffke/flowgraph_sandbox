<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ais_sigmf</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate, samp_rate/2, 50000, firdes.WIN_FLATTOP, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn</value></param>
<param><key>value</key><value>"{:s}_{:s}".format(signal_name, ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp</value></param>
<param><key>value</key><value>"/home/zleffke/captures/ais/{:s}".format(fn)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>162e6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>55</value></param>
<param><key>gui_hint</key><value>8,0,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>(samp_rate/decim/50*48)/baud</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ")</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>8,2,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>ais_invert</key>
<param><key>id</key><value>ais_invert_0</value></param>
</block>
<block>
<key>ais_invert</key>
<param><key>id</key><value>ais_invert_0_0</value></param>
</block>
<block>
<key>ais_pdu_to_nmea</key>
<param><key>id</key><value>ais_pdu_to_nmea_0</value></param>
<param><key>designator</key><value>A</value></param>
</block>
<block>
<key>ais_pdu_to_nmea</key>
<param><key>id</key><value>ais_pdu_to_nmea_0_0</value></param>
<param><key>designator</key><value>B</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-3</value></param>
<param><key>decay_rate</key><value>1e-1</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-3</value></param>
<param><key>decay_rate</key><value>1e-1</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(samp_rate/decim)/(2*math.pi*fsk_deviation/8.0)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>(samp_rate/decim)/(2*math.pi*fsk_deviation/8.0)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-25e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>tune</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>25e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zleffke/sandbox/ais/ais_20161216_250k_2.32fc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate*4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cyborg_version</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>v0.1.0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>11</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0_0</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>11</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>7e3</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>7e3</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_order</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_scheme</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>GMSK</value></param>
</block>
<block>
<key>pyqt_text_output</key>
<param><key>id</key><value>pyqt_text_output_0</value></param>
<param><key>gui_hint</key><value>4,4,1,4</value></param>
</block>
<block>
<key>pyqt_text_output</key>
<param><key>id</key><value>pyqt_text_output_0_0</value></param>
<param><key>gui_hint</key><value>4,0,1,4</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,2,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>"AIS"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,4,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_min</key><value>-60</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"AIS-A"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,4,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_min</key><value>-60</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"AIS-B"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,0,2,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>name</key><value>"Channel"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ant_model</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>COMET SMA703</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_db_ser</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>na</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_db_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>na</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ser_tag</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>30DCE50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ser_uhd</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>30DCE50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>B200</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value></value></param>
<param><key>description</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_extra_fields</key><value>13</value></param>
<param><key>field_1_key</key><value>"usrp:rx_type"</value></param>
<param><key>field_1_type</key><value>string</value></param>
<param><key>field_1_value</key><value>rx_type</value></param>
<param><key>field_10_key</key><value>"usrp:version"</value></param>
<param><key>field_10_type</key><value>string</value></param>
<param><key>field_10_value</key><value>v0.1.0</value></param>
<param><key>field_11_key</key><value>"usrp:rx_rf_gain"</value></param>
<param><key>field_11_type</key><value>float</value></param>
<param><key>field_11_value</key><value>rx_gain</value></param>
<param><key>field_12_key</key><value>"usrp:rx_freq"</value></param>
<param><key>field_12_type</key><value>float</value></param>
<param><key>field_12_value</key><value>rx_freq</value></param>
<param><key>field_13_key</key><value>"usrp:rx_ant_model"</value></param>
<param><key>field_13_type</key><value>string</value></param>
<param><key>field_13_value</key><value>rx_ant_model</value></param>
<param><key>field_14_key</key><value></value></param>
<param><key>field_14_type</key><value>string</value></param>
<param><key>field_14_value</key><value></value></param>
<param><key>field_15_key</key><value></value></param>
<param><key>field_15_type</key><value>string</value></param>
<param><key>field_15_value</key><value></value></param>
<param><key>field_16_key</key><value></value></param>
<param><key>field_16_type</key><value>string</value></param>
<param><key>field_16_value</key><value></value></param>
<param><key>field_17_key</key><value></value></param>
<param><key>field_17_type</key><value>string</value></param>
<param><key>field_17_value</key><value></value></param>
<param><key>field_18_key</key><value></value></param>
<param><key>field_18_type</key><value>string</value></param>
<param><key>field_18_value</key><value></value></param>
<param><key>field_19_key</key><value></value></param>
<param><key>field_19_type</key><value>string</value></param>
<param><key>field_19_value</key><value></value></param>
<param><key>field_2_key</key><value>"usrp:rx_ser_uhd"</value></param>
<param><key>field_2_type</key><value>string</value></param>
<param><key>field_2_value</key><value>rx_ser_uhd</value></param>
<param><key>field_20_key</key><value></value></param>
<param><key>field_20_type</key><value>string</value></param>
<param><key>field_20_value</key><value></value></param>
<param><key>field_21_key</key><value></value></param>
<param><key>field_21_type</key><value>string</value></param>
<param><key>field_21_value</key><value></value></param>
<param><key>field_22_key</key><value></value></param>
<param><key>field_22_type</key><value>string</value></param>
<param><key>field_22_value</key><value></value></param>
<param><key>field_23_key</key><value></value></param>
<param><key>field_23_type</key><value>string</value></param>
<param><key>field_23_value</key><value></value></param>
<param><key>field_24_key</key><value></value></param>
<param><key>field_24_type</key><value>string</value></param>
<param><key>field_24_value</key><value></value></param>
<param><key>field_25_key</key><value></value></param>
<param><key>field_25_type</key><value>string</value></param>
<param><key>field_25_value</key><value></value></param>
<param><key>field_3_key</key><value>"usrp:rx_ser_tag"</value></param>
<param><key>field_3_type</key><value>string</value></param>
<param><key>field_3_value</key><value>rx_ser_tag</value></param>
<param><key>field_4_key</key><value>"usrp:rx_db_type"</value></param>
<param><key>field_4_type</key><value>string</value></param>
<param><key>field_4_value</key><value>rx_db_type</value></param>
<param><key>field_5_key</key><value>"usrp:rx_db_ser"</value></param>
<param><key>field_5_type</key><value>string</value></param>
<param><key>field_5_value</key><value>rx_db_ser</value></param>
<param><key>field_6_key</key><value>"modulation:scheme"</value></param>
<param><key>field_6_type</key><value>string</value></param>
<param><key>field_6_value</key><value>mod_scheme</value></param>
<param><key>field_7_key</key><value>"modulation:order"</value></param>
<param><key>field_7_type</key><value>int</value></param>
<param><key>field_7_value</key><value>mod_order</value></param>
<param><key>field_8_key</key><value>"cyborg:symbol_rate"</value></param>
<param><key>field_8_type</key><value>float</value></param>
<param><key>field_8_value</key><value>symbol_rate</value></param>
<param><key>field_9_key</key><value>"cyborg:version"</value></param>
<param><key>field_9_type</key><value>string</value></param>
<param><key>field_9_value</key><value>cyborg_version</value></param>
<param><key>filename</key><value>fp</value></param>
<param><key>hardware</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>license</key><value></value></param>
<param><key>append</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>time_mode</key><value>gr_sigmf.sigmf_time_mode_absolute</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>AIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>ais-a</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>ais-b</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>bytes-a</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>bytes-b</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>ais-a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>ais-b</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>bytes-a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>bytes-b</value></param>
</block>
<connection><source_block_id>ais_invert_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ais_invert_0_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0</source_block_id><sink_block_id>pyqt_text_output_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ais_pdu_to_nmea_0_0</source_block_id><sink_block_id>pyqt_text_output_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>ais_invert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0</source_block_id><sink_block_id>ais_invert_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>ais_pdu_to_nmea_0</sink_block_id><source_key>out</source_key><sink_key>to_nmea</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0_0</source_block_id><sink_block_id>ais_pdu_to_nmea_0_0</sink_block_id><source_key>out</source_key><sink_key>to_nmea</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
