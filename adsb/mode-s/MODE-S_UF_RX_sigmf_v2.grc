<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>modes_uf_rx_sigmf_v2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>bit_thresh</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>6,4,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>burst_length</value></param>
<param><key>value</key><value>600</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>cons_offset</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>0,8,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>det_avg_len</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,9,1,1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>det_mult</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>0,6,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>es_thresh</value></param>
<param><key>value</key><value>110</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label</key><value>ES Thresh</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>qt_thresh</value></param>
<param><key>value</key><value>110</value></param>
<param><key>gui_hint</key><value>0,2,1,2 </value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>45</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rms_alpha</value></param>
<param><key>value</key><value>1e-6</value></param>
<param><key>gui_hint</key><value>6,3,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>alpha</key><value>0.4</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>32</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>sym_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>ais_invert</key>
<param><key>id</key><value>ais_invert_0</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>cons_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_1</value></param>
<param><key>scale</key><value>1/10.0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_1_0_0</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>int(det_avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/det_avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1*det_mult</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>thresh</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>1.0 / 65536.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>est_len</value></param>
<param><key>minoutbuf</key><value>burst_length</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>alpha</key><value>rms_alpha</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_1</value></param>
<param><key>alpha</key><value>rms_alpha</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_2_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2</value></param>
<param><key>access_code</key><value>011100000111000</value></param>
<param><key>comment</key><value>P1+P2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>P1_P2</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2_0</value></param>
<param><key>access_code</key><value>011100000111000</value></param>
<param><key>comment</key><value>P1+P2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>P1_P2</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2_2</value></param>
<param><key>access_code</key><value>010010000100100100001</value></param>
<param><key>comment</key><value>P1+P2+sync Encoded</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>sync</value></param>
<param><key>threshold</key><value>2</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2_2_0_0</value></param>
<param><key>access_code</key><value>1111111100011111000111000001</value></param>
<param><key>comment</key><value>P1+P2+sync Encoded</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>sync</value></param>
<param><key>threshold</key><value>2</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2_2_0_0_0</value></param>
<param><key>access_code</key><value>00011111000111000001</value></param>
<param><key>comment</key><value>P1+P2+sync Encoded</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>sync</value></param>
<param><key>threshold</key><value>3</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>math.pi / 50</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_phasor_cc</key>
<param><key>id</key><value>digital_diff_phasor_cc_0</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>32</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>math.pi/200</value></param>
<param><key>max_dev</key><value>1.1</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python


import numpy as np
import pmt
import binascii
import math
import datetime
import struct
import sys
from gnuradio import gr

# Uplink Format, 5 bits
# Aeronautical Telecommunications: Annex 10 to the Convention on International Civil Aviation, Volume IV Surveillance and Collision Avoidance Systems. International Civil Aviation Organization (ICAO), fifth edition, July 2015
# Figure 3-7. Summary of Mode S interrogation or uplink formats
# Page 3-91 (pdf page 115)
UF_STR_LUT = (
    'Short Air-Air Surveillance (ACAS)',
    'Reserved',
    'Reserved',
    'Reserved',
    'Surveillance Altitude Request',
    'Surveillance Identity Request',
    'Reserved',
    'Reserved',
    'Reserved',
    'Reserved',
    'Reserved',
    'Mode-S Only All-Call',
    'Reserved',
    'Reserved',
    'Reserved',
    'Reserved',
    'Long Air-Air Surveillance (ACAS)',
    'Reserved',
    'Reserved',
    'Reserved for Military Use',
    'Comm-B Altitude Request',
    'Comm-B Identity Request',
    'Reserved for Military Use',
    'Reserved',
    'Comm-D (ELM)'
)

class uf_decode(gr.sync_block):
    """
    Expected Upstream Block:  UF Sync (Uplink Frame Sync)
    Expected input:  PDU with 112 bits, UNPACKED byte format

    Goal:
        Attempts to decode packet, 
        determine UF type (i.e. UF0 = ACAS short air surveillance)
        Decode address (ICAO) and check parity

    Output:
        JSON Object with decoded information
    """
    def __init__(self, msg_filter='All Messages', verbose = True):
        gr.sync_block.__init__(self,
            name="UF Decode",
            in_sig=None,
            out_sig=None)

        self.msg_filter = msg_filter
        self.verbose = verbose
        self.message_port_register_in(pmt.intern("in"))
        self.set_msg_handler(pmt.intern('in'), self.handler)
        self.message_port_register_out(pmt.intern("out"))

        # Initialize plane dictionary
        self.plane_dict = dict([])

        self.decoded = {}
        
    def work(self, input_items, output_items):
        assert(false)


    def handler(self, pdu):

        # Grab packet PDU data
        meta = pmt.to_python(pmt.car(pdu))
        vector = pmt.cdr(pdu)
        if not pmt.is_u8vector(vector):
            print "[ERROR] Received invalid message type. Expected u8vector"
            return

        vector = pmt.to_python(pmt.cdr(pdu))

        self.snr = meta['snr']
        self.meta = meta
        # print 'vector\n', vector
        # print 'vector.dtype\n', vector.dtype
        # print 'type(vector)\n', type(vector)
        self.bits = vector

        #print meta
        #print self.bits
        
        #data = list(pmt.u8vector_elements(msg))
        #packed = self._pack_bytes(data)
        #hex_str = binascii.hexlify(packed)
        #print data, hex_str
        #self._decode_type(packed)
        try:
            self._decode_header()
            self._parse_payload()
            parity_passed = self._check_parity()
        except Exception as e: # catch *all* exceptions
            print e
        #print self.decoded


    

    


    # http://www.bucharestairports.ro/files/pages_files/Vol_IV_-_4yh_ed,_July_2007.pdf
    # http://www.icao.int/APAC/Documents/edocs/cns/SSR_%20modesii.pdf
    # http://www.anteni.net/adsb/Doc/1090-WP30-18-DRAFT_DO-260B-V42.pdf
    # http://www.cats.com.kh/download.php?path=vdzw4dHS08mjtKi6vNi31Mbn0tnZ2eycn6ydmqPE19rT7Mze4cSYpsetmdXd0w==
    # http://www.sigidwiki.com/images/1/15/ADS-B_for_Dummies.pdf
    def _decode_header(self):  
        # Uplink Format, 5 bits
        self.uf = self.bin2dec(self.bits[0:0+5])
        self.uf_str = "UF{:d}".format(self.uf)
        if self.uf in [0,4,5]:
            # 56 bit payload
            self.payload_length = 56
            self.payload = self.bits[0:self.payload_length]
            #print len(self.payload), self.payload
 
    def bin2dec(self, bits):
        return int(''.join(map(str, bits)), 2)

    def _parse_payload(self):
        if self.uf_str == 'UF0':
            self.rl = self.payload[8]
            self.aq = self.payload[13]
            self.ds = self.payload[14:22]
            self.ap = self.payload[32:32+24]
            
            if self.verbose:
                #print '\n'
                print '----------------------------------------------------------------------'
                print self.meta
                print len(self.payload), self.payload
                print 'datetime: {:s}'.format(self.meta['datetime'])
                print '     SNR: {:2.2f} dB'.format(self.meta['snr'])
                print '    SYNC: {:d}'.format(self.meta['sync'])
                print '      UF: {:d} {:s}'.format(self.uf, UF_STR_LUT[self.uf])
                print '      RL: {:d}'.format(self.rl)
                print '      AQ: {:d}'.format(self.aq)
                print '      DS: 0x{:04x}'.format(self.bin2dec(self.ds))
                print ' bits AP:', self.ap
                print '  hex AP: 0x{:06x}'.format(self.bin2dec(self.ap))

            #Create output pdu and emit
            meta = pmt.to_pmt(self.meta)
            vector = pmt.to_pmt(self.payload)
            pdu = pmt.cons(meta, vector)
            self.message_port_pub(pmt.intern('out'), pdu)

    

    # http://jetvision.de/sbs/adsb/crc.htm
    def _check_parity(self):
        # DF CRC polynomial (0xFFFA048) = 1 + x + x^2 + x^3 + x^4 + x^5 + x^6 + x^7 + x^8 + x^9 + x^10 + x^11 + x^12 + x^14 + x^21 + x^24
        crc_poly = np.array([1,1,1,1,1,1,1,1,1,1,1,1,1,0,1,0,0,0,0,0,0,1,0,0,1])        
        # UF CRC polynomial (0x1205FFF) = 1 + x^3 + x^10 + x^12 + x^13 + x^14 + x^15 + X^16 + x^17 + x^18 + x^19 + X^20 + x^21 + x^22 + x^23 + x^24
        #crc_poly = np.array([1,0,0,1,0,0,0,0,0,0,1,0,1,1,1,1,1,1,1,1,1,1,1,1,1])

        if self.uf in [0,4,5]:
            # 56 bit payload
            self.payload_length = 56
            #payload = self.bits[0:self.payload_length]
            #print len(payload), payload

            # Address/Parity, 24 bits
            ap_bits = self.bits[32:32+24]
            crc_bits = self.compute_crc(self.bits[0:self.payload_length-24], crc_poly)            
            crc = self.bin2dec(crc_bits)

            # XOR the computed CRC with the AP, the result should be the
            # interrogated plane's ICAO address
            self.aa_bits = crc_bits ^ ap_bits
            self.aa = self.bin2dec(self.aa_bits)
            self.aa_str = '%06x' % (self.aa)

            parity_passed = self.plane_dict.has_key(self.aa_str) == True
            if parity_passed:
                self.plane_dict[self.aa_str] += 1
            else:
                self.plane_dict[self.aa_str] = 0

            if self.verbose:
                print '      AA: 0x{:06x}'.format(self.aa)
                print 'AA count: {:d}'.format(self.plane_dict[self.aa_str])
                print '----------------------------------------------------------------------'

        return 0




    # http://jetvision.de/sbs/adsb/crc.htm
    def _check_parity_old(self):
        # DF CRC polynomial (0xFFFA048) = 1 + x + x^2 + x^3 + x^4 + x^5 + x^6 + x^7 + x^8 + x^9 + x^10 + x^11 + x^12 + x^14 + x^21 + x^24
        crc_poly = np.array([1,1,1,1,1,1,1,1,1,1,1,1,1,0,1,0,0,0,0,0,0,1,0,0,1])        
        # UF CRC polynomial (0x1205FFF) = 1 + x^3 + x^10 + x^12 + x^13 + x^14 + x^15 + X^16 + x^17 + x^18 + x^19 + X^20 + x^21 + x^22 + x^23 + x^24
        #crc_poly = np.array([1,0,0,1,0,0,0,0,0,0,1,0,1,1,1,1,1,1,1,1,1,1,1,1,1])

        if self.msg_filter == 'All Messages':
            if self.uf in [0,4,5]:
                # 56 bit payload
                self.payload_length = 56
                payload = self.bits[0:self.payload_length]
                print len(payload), payload

                # Address/Parity, 24 bits
                ap_bits = self.bits[32:32+24]

                crc_bits = self.compute_crc(self.bits[0:self.payload_length-24], crc_poly)            
                crc = self.bin2dec(crc_bits)

                # XOR the computed CRC with the AP, the result should be the
                # interrogated plane's ICAO address
                self.aa_bits = crc_bits ^ ap_bits
                self.aa = self.bin2dec(self.aa_bits)
                self.aa_str = '%06x' % (self.aa)

                # If the ICAO address is in our plane dictionary,
                # then it's safe to assume the CRC passes
                parity_passed = self.plane_dict.has_key(self.aa_str) == True

                if parity_passed == True:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Passed (Recognized AA from AP)'
                        print 'AA:'.ljust(16) + '%s' % (self.aa_str)
                    return 1
                else:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Failed (Unrecognized AA from AP)'
                        print 'AA:'.ljust(16) + '%s' % (self.aa_str)
                    return 0

            elif self.uf in [11]:
                # 56 bit payload
                self.payload_length = 56

                # Parity/Interrogator ID, 24 bits
                pi_bits = self.bits[32:32+24]
                pi = self.bin2dec(pi_bits)

                crc_bits = self.compute_crc(self.bits[0:self.payload_length-24], crc_poly)            
                crc = self.bin2dec(crc_bits)

                # result_bits = pi_bits ^ crc_bits
                # print 'pi_bits', pi_bits
                # print 'crc_bits', crc_bits
                # print 'result_bits', result_bits
                # parity_passed = (pi_bits[:7] == crc_bits[:7])

                parity_passed = (pi == crc)

                # 17 0s
                # Code Label, 3 bits (3.1.2.5.2.1.3)
                # Interrogator Code, 4 bits (3.1.2.5.2.1.2)

                if parity_passed == True:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Passed'
                    return 1
                else:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Failed (PI-CRC = %d)' % (pi-crc)
                    return 0

            elif self.uf in [16,20,21,24]:
                # 112 bit payload
                self.payload_length = 112

                # Address/Parity, 24 bits
                ap_bits = self.bits[88:88+24]

                crc_bits = self.compute_crc(self.bits[0:self.payload_length-24], crc_poly)            
                crc = self.bin2dec(crc_bits)

                # XOR the computed CRC with the AP, the result should be the
                # interrogated plane's ICAO address
                self.aa_bits = crc_bits ^ ap_bits
                self.aa = self.bin2dec(self.aa_bits)
                self.aa_str = '%06x' % (self.aa)

                # If the ICAO address is in our plane dictionary,
                # then it's safe to assume the CRC passes
                parity_passed = self.plane_dict.has_key(self.aa_str) == True

                if parity_passed == True:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Passed (Recognized AA from AP)'
                        print 'AA:'.ljust(16) + '%s' % (self.aa_str)
                    return 1
                else:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Failed (Unrecognized AA from AP)'
                        print 'AA:'.ljust(16) + '%s' % (self.aa_str)
                    return 0

        if self.msg_filter == 'All Messages' or self.msg_filter == 'Extended Squitter Only':
            if self.uf in [17,18,19]:
                # 112 bit payload
                self.payload_length = 112

                # Parity/Interrogator ID, 24 bits
                pi = self.bin2dec(self.bits[88:88+24])

                crc_bits = self.compute_crc(self.bits[0:self.payload_length-24], crc_poly)
                crc = self.bin2dec(crc_bits)

                parity_passed = (pi == crc)

                if parity_passed == True:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Passed'
                    return 1
                else:
                    if self.verbose:
                        print 'CRC:'.ljust(16) + 'Failed (PI-CRC = %d)' % (pi-crc)
                    return 0

        # Unsupported downlink format
        #print 'Unsupported downlink format'
        return 0 # Parity failed


    # http://www.radarspotters.eu/forum/index.php?topic=5617.msg41293#msg41293
    # http://www.eurocontrol.int/eec/gallery/content/public/document/eec/report/1994/022_CRC_calculations_for_Mode_S.pdf
    def compute_crc(self, data, poly):
        print data
        num_data_bits = len(data)
        num_crc_bits = len(poly)-1

        # Multiply the data by x^(num_crc_bits), which is equivalent to a 
        # left shift operation which is equivalent to appending zeros
        data = np.append(data, np.zeros(num_crc_bits, dtype=int))

        for ii in range(0,num_data_bits):
            if data[ii] == 1:
                # XOR the data with the CRC polynomial
                # NOTE: The data polynomial and CRC polynomial are Galois Fields
                # in GF(2)
                data[ii:ii+num_crc_bits+1] ^= poly

        crc = data[num_data_bits:num_data_bits+num_crc_bits]

        return crc

    def _decode_type_old(self,data):
        print type(data), binascii.hexlify(data)
        
        #Frame Type:  bits 0-4 (1-5)
        a = data[0]
        uf = (a &gt;&gt; 3) &amp; 0x1F #Hi Nibble
        if self.verbose: 
            #print "Type field: {:08b}".format(uf)
            if    uf==0: print "DF0: Short Air-to-air surveillance (ACAS)"
            elif  uf==4: print "DF4: Surveillance, altitude request"
            elif  uf==5: print "DF5: Surveillance, identify request"
            elif uf==11: print "DF11: Mode-S only all call"
            elif uf==16: print "DF16: Long Air-to-air surveillance (ACAS)"
            elif uf==20: print "DF20: Comm-A, altitude request"
            elif uf==21: print "DF21: Comm-A, identify request"
            elif uf==21: print "DF21: Comm-A, identify request"
            elif uf==24: print "DF24: Comm-C, ELM"
            elif uf==19 or uf==22: print "DF{:d}: Reserved, Military Use".format(uf)
            else: print "DF{:d}: Reserved".format(uf)
        self.decoded['type'] = "UF{:d}".format(uf)
        
        #RL And AQ
        rl_aq_byte = data[1]
        self.decoded['RL'] = (rl_aq_byte &gt;&gt; 7) &amp; 0x01
        self.decoded['AQ'] = (rl_aq_byte &gt;&gt; 1) &amp; 0x01

        #BDS
        bds_bytes = data[1:3]
        if self.verbose: 
            print len(bds_bytes), numpy.uint16(bds_bytes)# &amp; 0xFFFF)

        bds = numpy.uint16(struct.unpack('&lt;H',bds_bytes))[0] # &gt;&gt; 1) &amp; 0x7FFFFF)
        
        print bds, binascii.hexlify(data[1:3]), binascii.hexlify(bds)
        #self.decoded['BDS'] = binascii.hexlify(numpy.uint16(bds_bytes &amp; 0xFF))

    # http://www.bucharestairports.ro/files/pages_files/Vol_IV_-_4yh_ed,_July_2007.pdf
    # http://www.icao.int/APAC/Documents/edocs/cns/SSR_%20modesii.pdf
    # http://www.anteni.net/adsb/Doc/1090-WP30-18-DRAFT_DO-260B-V42.pdf
    # http://www.cats.com.kh/download.php?path=vdzw4dHS08mjtKi6vNi31Mbn0tnZ2eycn6ydmqPE19rT7Mze4cSYpsetmdXd0w==
    # http://www.sigidwiki.com/images/1/15/ADS-B_for_Dummies.pdf
    def _decode_header_old(self):  
        # Uplink Format, 5 bits
        self.uf = self.bin2dec(self.bits[0:0+5])
        self.uf_str = "UF{:d}".format(self.uf)
        if self.uf &lt;=24:
            if self.verbose:
                if self.msg_filter == 'All Messages':
                    print '\n'
                    print '----------------------------------------------------------------------'
                    print 'datetime:'.ljust(16) + '%s' % (self.meta['datetime'])
                    print 'SNR:'.ljust(16) + '%1.2f dB' % (self.meta['snr'])
		            #print 'UF{:d}'.format(self.uf)
                    print 'UF:'.ljust(16) + '%d %s' % (self.uf, UF_STR_LUT[self.uf])


    def _pack_bytes_old(self, unpacked):
        #self.msg_count += 1
        a = [int("".join(map(str, unpacked[i:i+8])), 2) for i in range(0, len(unpacked), 8)]
        packed = bytearray(a)
        return packed
</value></param>
<param><key>msg_filter</key><value>'All Messages'</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python


import numpy
import pmt
import binascii
import numpy
import math
import datetime
from gnuradio import gr

SEARCH = 1
COPY = 2

class uf_frame_sync(gr.sync_block):
    """
    Expects Correlate Access Code - Tag block upstream.
    Tag indicates the last bit of the UF frame sync
    Operates on unpacked byte stream.

    Logic:
     Detects a packet tag.
     pulls out the following 112 bits (max UF frame)
     Emits a PMT/PDU Message of decoded frame
    
    Time Control:
     If 'rx_time' tag exists (from UHD / SigMF), use to create 'datetime'

    OUTPUT:
     async PDU with metadata and UNPACKED 112 bit frame

    """
    def __init__(self, tag_name="packet", msg_len=112, samp_rate = 8e6, sps = 2):
        gr.sync_block.__init__(self,
            name="(UF) Sync",
            in_sig=[numpy.int8],
            out_sig=None)

        self.tag_name = tag_name
        self.offset_key = self.tag_name + "_offset"
        self.message_port_register_out(pmt.intern("out"))
        self.msg_len = msg_len
        self.samp_rate = samp_rate
        self.sps = sps
        self.samp_period = 1.0 / (samp_rate/sps) #seconds per sample
        
    def work(self, input_items, output_items):
        in0 = input_items[0]
        num_input_items = len(in0)
        return_value = num_input_items
        nread = self.nitems_read(0)

        #read in all tags - convert to dict
        tags = self.get_tags_in_window(0, 0, num_input_items)
        self.tag = {}
        for t in tags:
            key = pmt.to_python(t.key) # convert from PMT to python string
            value = pmt.to_python(t.value) 
            self.tag[key] = value
            if key == self.tag_name:
                offset = t.offset
                self.tag[self.offset_key] = offset-nread #offset within window
        
        #look for specific trigger tag (probably 'sync') to indicate frame delimiter
        if all(x in self.tag.keys() for x in [self.tag_name, 'rx_time', 'es::event_time']):
            #print self.tag[self.tag_name]
            if self.tag[self.tag_name] == 1:
                idx_start = self.tag[self.offset_key]
            else: 
                idx_start = self.tag[self.offset_key]+1
            idx_stop  = idx_start + self.msg_len
            msg = in0[idx_start:idx_stop]
            
            #Correct timestamp for sample offset in window            
            time_offset = self.samp_period * self.tag[self.offset_key]
            time_delta = self.tag['es::event_time'] / (self.samp_rate * self.sps)
            rx_int_sec = self.tag['rx_time'][1][0]
            rx_frac_sec = self.tag['rx_time'][1][1]
            td = math.modf(time_delta)
            dt = (numpy.int64(rx_int_sec + td[1]) , rx_frac_sec + td[0])
            ts = numpy.datetime64(datetime.datetime.utcfromtimestamp(dt[0]))
            ts = ts + numpy.timedelta64(int(dt[1]*1e9), 'ns') + numpy.timedelta64(int(time_offset*1e9), 'ns')
            ts_ns = numpy.datetime_as_string(ts) +"Z"
            self.tag['datetime'] = ts_ns
            
            #Create output pdu and emit
            meta = pmt.to_pmt(self.tag)
            vector = pmt.to_pmt(msg)
            pdu = pmt.cons(meta, vector)
            self.message_port_pub(pmt.intern('out'), pdu)
        
        return num_input_items


</value></param>
<param><key>msg_len</key><value>112</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>tag_name</key><value>'sync'</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>burst_length</value></param>
<param><key>lookback</key><value>burst_length /3</value></param>
<param><key>guard</key><value>300</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>es_thresh</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import time; import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>3e6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>250e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>4e6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>250e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>mapper_demapper_soft</key>
<param><key>id</key><value>mapper_demapper_soft_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0</value></param>
<param><key>gui_hint</key><value>1,6,2,2</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>gui_hint</key><value>1,4,2,2</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,8,2,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>burst_length/2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>3,5,3,5</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>ncols</key><value>56</value></param>
<param><key>nrows</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate / 2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,5,3,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>chips</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>burst_length/2/2*0 + 56</value></param>
<param><key>srate</key><value>samp_rate/2</value></param>
<param><key>tr_delay</key><value>1.0/(samp_rate/2)*10</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"P1_P2"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>3</value></param>
<param><key>ymin</key><value>-3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>3,0,3,5</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>re</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>alpha2</key><value>0.25</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>abs</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>mag</value></param>
<param><key>marker3</key><value>0</value></param>
<param><key>name</key><value>"soft chips"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>burst_length/2</value></param>
<param><key>srate</key><value>samp_rate/2</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"es::event_type"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,0,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>burst_length/2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>1.0/samp_rate *100</value></param>
<param><key>tr_level</key><value>qt_thresh</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_0</value></param>
<param><key>filename</key><value>/captures/adsb/20210127/MODE-S_2021-01-27T23:43:24.sigmf-data</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>vcc_burst_snr</key>
<param><key>id</key><value>vcc_burst_snr_0</value></param>
<param><key>length</key><value>25</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>vcc_es_tag_to_utc</key>
<param><key>id</key><value>vcc_es_tag_to_utc_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>burst_iq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>trigger</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4_0</value></param>
<param><key>stream_id</key><value>corrected_iq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>soft_bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>burst_iq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>trigger</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4_0_0</value></param>
<param><key>stream_id</key><value>corrected_iq</value></param>
</block>
<connection><source_block_id>ais_invert_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1_0_0</source_block_id><sink_block_id>blocks_sub_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_sub_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>vcc_burst_snr_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>blocks_sub_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_1</source_block_id><sink_block_id>digital_binary_slicer_fb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_2_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>ais_invert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2</source_block_id><sink_block_id>digital_diff_decoder_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_2</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_2_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_2_0_0_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>mapper_demapper_soft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>virtual_sink_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_1</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_phasor_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_phasor_cc_0</source_block_id><sink_block_id>blocks_rms_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>epy_block_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_soft_0</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vcc_burst_snr_0</source_block_id><sink_block_id>vcc_es_tag_to_utc_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>pyqt_const_plot_0</sink_block_id><source_key>out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4_0_0</source_block_id><sink_block_id>digital_diff_phasor_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
