<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>(samp_rate/decim*(24.0/25.0))/ baud</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate / decim * 24 / 25)</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate / decim * 24 / 25)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>w</key><value>math.pi/200</value></param>
<param><key>max_freq</key><value>math.pi/10</value></param>
<param><key>min_freq</key><value>-math.pi/10</value></param>
</block>
<block>
<key>analog_pll_freqdet_cf</key>
<param><key>id</key><value>analog_pll_freqdet_cf_0</value></param>
<param><key>w</key><value>math.pi/200</value></param>
<param><key>max_freq</key><value>math.pi/10</value></param>
<param><key>min_freq</key><value>-math.pi/10</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/zleffke/captures/sarsat/NOAA18_20161115_131537.305805540_UTC_500k.c32</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>int(samp_rate*meta_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>10000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>0.0001</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>samp_rate/(2*math.pi)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>8000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"rfo"</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>rfo</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samps_per_symb*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>010000101011101100011111</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>pds_sync</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decim</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,4,3,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_0</value></param>
<param><key>gui_hint</key><value>3,4,1,4</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Freq Offset</value></param>
<param><key>unit1</key><value>Hz</value></param>
<param><key>max</key><value>32767</value></param>
<param><key>min</key><value>-32767</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate/decim/25*24/samps_per_symb/2</value></param>
<param><key>tr_delay</key><value>2000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"pds_sync"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,4,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>sarsat_biphase_l_decode_bb</key>
<param><key>id</key><value>sarsat_biphase_l_decode_bb_0</value></param>
</block>
<block>
<key>sarsat_pds_frame_sync</key>
<param><key>id</key><value>sarsat_pds_frame_sync_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>tag_name</key><value>pds_sync</value></param>
</block>
<block>
<key>sarsat_sarp_msg_extract</key>
<param><key>id</key><value>sarsat_sarp_msg_extract_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tap_1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>freq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>tap_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>freq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>analog_pll_freqdet_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_freqdet_cf_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>sarsat_biphase_l_decode_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sarsat_biphase_l_decode_bb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sarsat_pds_frame_sync_0</source_block_id><sink_block_id>sarsat_sarp_msg_extract_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sarsat_sarp_msg_extract_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>valid</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>sarsat_sarp_msg_extract_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>valid</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>sarsat_pds_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
