<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>modes_rx_fosphor</value></param>
<param><key>author</key><value>Zach Leffke</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>MODE-S Spectrum Monitor</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>band_select_qt</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>9,2,1,1</value></param>
<param><key>label0</key><value>1030 MHz</value></param>
<param><key>label1</key><value>1090 MHz</value></param>
<param><key>label2</key><value>CUSTOM</value></param>
<param><key>label</key><value>Channel Select</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>custom_freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>gui_hint</key><value>9,1,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>[1030e6, 1090e6, custom_freq]</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gain_ota</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>label</key><value>Gain (dB)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gain_wired</value></param>
<param><key>value</key><value>40</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>9,4,1,2</value></param>
<param><key>label</key><value>Gain (dB)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ota_serial</value></param>
<param><key>comment</key><value>RB1311 roof</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"serial=3070390"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ota_serial</value></param>
<param><key>comment</key><value>flatscreen</value></param>
<param><key>value</key><value>"serial=3070390"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ota_serial</value></param>
<param><key>comment</key><value>flatscreen</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"serial=30C62B1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ota_str</value></param>
<param><key>value</key><value>"Over The Air: {:3.1f} MHz".format(fc[band_select_qt]/1e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ota_str_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"Over The Air: {:3.1f} MHz".format(fc[band_select_qt]/1e6)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>gui_hint</key><value>9,3,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>ota_str</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label</key><value>Spectrum</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>"TTR920 TJ1 1030 MHz Wired"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,4,1,4</value></param>
<param><key>label</key><value>Spectrum:</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wired_serial</value></param>
<param><key>comment</key><value>RB1311 roof</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"serial=30C629C"</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,8,4</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,4,8,4</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>10,0,1,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(fc[band_select_qt], samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_ota</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>ota_serial</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(1030e6, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_wired</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>wired_serial</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
