options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: sigmf_adsb_playback
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,6,1,2
    type: real
    value: 1.5e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,2
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10e6 '
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,6,1,2
    label: Detection Threshold
    type: real
    value: '10'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"All Messages"'
    print_level: '"None"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: samp_rate
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: samp_rate
    threshold: threshold
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-6'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/8
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 'samp_rate '
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: fosphor_qt_sink_c_1
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate/10*4
    gui_hint: 0,0,4,4
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/10*4
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,2,4
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,4,1,4
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: int(samp_rate*1*150e-6)
    srate: int(samp_rate*1)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymax: '100'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '40'
  states: {state: disabled}
- name: sigmf_source_0
  id: sigmf_source
  parameters:
    filename: /captures/20191211/ADSB_2019-12-11T22:34:43Z.sigmf-data
    repeat: 'False'
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: power
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: raw_pdu
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: power
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: raw_pdu
  states: {}

connections:
- [adsb_decoder_0, decoded, virtual_sink_0_0, '0']
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', fosphor_qt_sink_c_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [sigmf_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', adsb_framer_1, '0']
- [virtual_source_0_0, '0', blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
