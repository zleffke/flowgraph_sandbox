options:
  parameters:
    generate_options: qt_gui
    id: nexrad_playback_sigmf
    output_language: python
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,7,1,1
    type: real
    value: '0.01'
  states: {}
- name: alpha_0
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,6,1,1
    type: real
    value: '1'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: look_ahead
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,6,1,1
    type: int
    value: '10'
  states: {}
- name: lpf_cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,4,1,1
    type: real
    value: .45e6
  states: {}
- name: lpf_trans
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,5,1,1
    type: real
    value: 500e3
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,4,1,2
    type: real
    value: 15e6
  states: {}
- name: thresh_hi
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,6,1,1
    type: real
    value: '10000'
  states: {}
- name: thresh_lo
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,7,1,1
    type: real
    value: '10000'
  states: {}
- name: throttle_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,5,1,1
    type: real
    value: '0.5'
  states: {}
- name: trig_lvl
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,4,1,1
    type: real
    value: '30'
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,4,1,2
    type: real
    value: 1e6
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tune
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'True'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0 / 65536.0
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_lo
    init: '0'
    low: thresh_hi
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*throttle_rate
    type: short
    vlen: '2'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate /decim
    gui_hint: 0,0,8,4
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: lpf_trans
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,0,8,4
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,4,3,4
    label1: ''
    size: 1024*16*100
    srate: samp_rate / decim
    tr_level: trig_lvl
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '50'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 7,4,1,4
    label1: ''
    size: 1024*16*100
    srate: samp_rate / decim
    tr_level: '.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '0'
  states: {}
- name: sigmf_source_0
  id: sigmf_source
  parameters:
    filename: /captures/20191214/NEXRAD_2019-12-14T23:24:46Z.sigmf-data
    repeat: 'True'
    type: sc16
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_0
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: corrected
  states: {}

connections:
- [analog_agc2_xx_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', analog_agc2_xx_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', fosphor_qt_sink_c_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [sigmf_source_0, '0', blocks_throttle_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_threshold_ff_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
