<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtlsdr_v3_dual_WWV_1</value></param>
<param><key>author</key><value>Zach Leffke, KJ4QLP</value></param>
<param><key>description</key><value>Analyze power, doppler, polarization of WWV emissions</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Dual RTL-SDR, WWV Receiver / Analyzer</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>agc_on_off</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@0:4,6,1,2</value></param>
<param><key>label0</key><value>ON</value></param>
<param><key>label1</key><value>OFF</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_0</value></param>
<param><key>value</key><value>"NS"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_1</value></param>
<param><key>value</key><value>"EW"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_attack</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,1,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_decay</value></param>
<param><key>value</key><value>100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,2,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,4,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_lpf_cut</value></param>
<param><key>value</key><value>5e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:8,4,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_max_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,5,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate_in</value></param>
<param><key>value</key><value>samp_rate/(decim_1*decim_2) *(interp_1*interp_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate_out</value></param>
<param><key>value</key><value>audio_rate_in/3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>audio_ref</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,3,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>audio_sel_rb</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:8,5,1,3</value></param>
<param><key>labels</key><value>["NS/EW","LHCP/RHCP",]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2,3,4,5]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_select</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>((1,0),(0,1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_ms</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>decay_rate</value></param>
<param><key>value</key><value>100e-6</value></param>
<param><key>gui_hint</key><value>main_tab@0:4,4,1,2</value></param>
<param><key>label0</key><value>Fast</value></param>
<param><key>label1</key><value>Medium</value></param>
<param><key>label2</key><value>Slow</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>100e-6</value></param>
<param><key>option1</key><value>65e-3</value></param>
<param><key>option2</key><value>20e-3</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_1</value></param>
<param><key>value</key><value>2048*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_2</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:8,0,1,1</value></param>
<param><key>label</key><value>corr_delay</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn_0</value></param>
<param><key>value</key><value>"{:s}_{:s}_{:s}".format(signal_type.upper(), antenna_0.upper(),ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn_1</value></param>
<param><key>value</key><value>"{:s}_{:s}_{:s}".format(signal_type.upper(), antenna_1.upper(),ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fn_wav</value></param>
<param><key>value</key><value>"{:s}_{:s}_{:s}.wav".format(signal_type.upper(), pol.upper(),ts_str)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp_0</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn_0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp_1</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn_1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fp_wav</value></param>
<param><key>value</key><value>"{:s}/{:s}".format(path, fn_wav)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_1</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_2</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>lpf_cut</value></param>
<param><key>value</key><value>3e3</value></param>
<param><key>gui_hint</key><value>main_tab@1:8,0,1,2</value></param>
<param><key>label</key><value>Freq [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>1024*64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>samp_rate/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_shift_complex</value></param>
<param><key>comment</key><value>90 deg = pi/2 rad</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>complex(math.cos(phase_shift_rad),math.sin(phase_shift_rad))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_shift_rad</value></param>
<param><key>comment</key><value>90 deg = pi/2 rad</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>math.pi/2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>pll_freq</value></param>
<param><key>value</key><value>100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,7,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>pll_lbw</value></param>
<param><key>value</key><value>200</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:9,6,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pol</value></param>
<param><key>value</key><value>"linear"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@0:4,3,1,1</value></param>
<param><key>label</key><value>PPM</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>15e6 </value></param>
<param><key>gui_hint</key><value>main_tab@0:4,0,1,2</value></param>
<param><key>label</key><value>Freq [Hz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>main_tab@0:4,2,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sel_agc_in</value></param>
<param><key>value</key><value>[((1,),(0,)),((0,),(1,)),]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sel_agc_out</value></param>
<param><key>value</key><value>[(1,0),(0,1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts_str</value></param>
<param><key>value</key><value>dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%SZ")</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vol_left</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:7,0,1,4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vol_right</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:8,0,1,4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>0.1</value></param>
<param><key>decay_rate</key><value>decay_rate</value></param>
<param><key>gain</key><value>1000</value></param>
<param><key>max_gain</key><value>65000</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>0.1</value></param>
<param><key>decay_rate</key><value>decay_rate</value></param>
<param><key>gain</key><value>1000</value></param>
<param><key>max_gain</key><value>65000</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0_0</value></param>
<param><key>attack_rate</key><value>audio_attack</value></param>
<param><key>decay_rate</key><value>audio_decay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>audio_gain</value></param>
<param><key>max_gain</key><value>audio_max_gain</value></param>
<param><key>reference</key><value>audio_ref</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0_0_0</value></param>
<param><key>attack_rate</key><value>audio_attack</value></param>
<param><key>decay_rate</key><value>audio_decay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>audio_gain</value></param>
<param><key>max_gain</key><value>audio_max_gain</value></param>
<param><key>reference</key><value>audio_ref</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>math.pi/pll_lbw</value></param>
<param><key>max_freq</key><value>math.pi/pll_freq</value></param>
<param><key>min_freq</key><value>-math.pi/pll_freq</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>math.pi/pll_lbw</value></param>
<param><key>max_freq</key><value>math.pi/pll_freq</value></param>
<param><key>min_freq</key><value>-math.pi/pll_freq</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-1 * (offset)</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>16000</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-nfft/2.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(delay)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>nfft</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>10</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>.1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>vol_left</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>vol_right</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>1.0/(audio_rate_out) *c_ms / 1000.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>1.0/(audio_rate_out) * 1e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0_0</value></param>
<param><key>comment</key><value>-90 deg phase shift</value></param>
<param><key>const</key><value>complex(0,-1)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_1</value></param>
<param><key>comment</key><value>+90 deg phase shift</value></param>
<param><key>const</key><value>complex(0,1)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>sel_agc_in[agc_on_off]</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>(sel_agc_out[agc_on_off],)</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>(sel_agc_out[agc_on_off],)</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>sel_agc_in[agc_on_off]</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>(audio_select[audio_sel_rb],)</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>(audio_select[audio_sel_rb],)</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>50e3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>50e3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>fp_wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>audio_rate_out</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_2</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string; import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>lpf_cut</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate_in</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>audio_lpf_cut</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate_out</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>audio_lpf_cut</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate_out</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>lpf_cut</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate_in</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>main_tab</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>Channel</value></param>
<param><key>label1</key><value>Filter + Resamp</value></param>
<param><key>label2</key><value>Xcorr</value></param>
<param><key>label3</key><value>Power</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq - offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>args</key><value>"rtl=0,direct_samp=2"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq-offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>args</key><value>"rtl=1,direct_samp=2"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/captures/radio_jove"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate / decim_1 *interp_1</value></param>
<param><key>fc</key><value>rx_freq*0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>N/S</value></param>
<param><key>label2</key><value>E/W</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/(decim_1*decim_2) *(interp_1*interp_2)</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,0,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>N/S</value></param>
<param><key>label2</key><value>E/W</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>bw</key><value>audio_rate_in</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,4,4,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>RHCP</value></param>
<param><key>label2</key><value>LHCP</value></param>
<param><key>name</key><value>"Cpol"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>audio_rate_out</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@2:0,0,4,8</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>NS-Left</value></param>
<param><key>label2</key><value>EW-Right</value></param>
<param><key>name</key><value>"Audio Spectrum"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>accum</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@3:4,4,2,4</value></param>
<param><key>label1</key><value>Range Delta [km]</value></param>
<param><key>xmax</key><value>25.0*1.0/(audio_rate_out) *c_ms / 1000.0</value></param>
<param><key>xmin</key><value>-25.0*1.0/(audio_rate_out) *c_ms / 1000.0</value></param>
<param><key>bins</key><value>2000</value></param>
<param><key>size</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0_0</value></param>
<param><key>accum</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@3:0,0,4,4</value></param>
<param><key>label1</key><value>Correlation Magnitude</value></param>
<param><key>xmax</key><value>1e4</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>bins</key><value>1000</value></param>
<param><key>size</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@3:6,0,1,2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Delay</value></param>
<param><key>unit1</key><value>[usec]</value></param>
<param><key>label3</key><value>Range Delta</value></param>
<param><key>unit3</key><value>[km]</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@2:7,4,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>NS - Left</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>EW - Right</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_rate_out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@3:4,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>10</value></param>
<param><key>srate</key><value>audio_rate_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ylabel</key><value>Range Delta [km]</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-20</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>main_tab@2:0,0,4,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>nfft</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim_1*interp_1</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,4,2,4</value></param>
<param><key>name</key><value>"N/S"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim_1*interp_1</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@0:2,4,2,4</value></param>
<param><key>name</key><value>"E/W"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate/(decim_1*decim_2) *(interp_1*interp_2)</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:6,0,2,4</value></param>
<param><key>name</key><value>"E/W"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_0_0</value></param>
<param><key>bw</key><value>audio_rate_in</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:6,4,2,4</value></param>
<param><key>name</key><value>"LHCP"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate/(decim_1*decim_2) *(interp_1*interp_2)</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:4,0,2,4</value></param>
<param><key>name</key><value>"N/S"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1_0</value></param>
<param><key>bw</key><value>audio_rate_in</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:4,4,2,4</value></param>
<param><key>name</key><value>"RHCP"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>audio_rate_out</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>main_tab@2:4,4,2,4</value></param>
<param><key>label1</key><value>EW-Right</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1_0</value></param>
<param><key>bw</key><value>audio_rate_out</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>main_tab@2:4,0,2,4</value></param>
<param><key>label1</key><value>NS-Left</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1_1</value></param>
<param><key>bw</key><value>audio_rate_in</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>main_tab@3:0,0,4,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>decim_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>interp_1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>decim</key><value>decim_2</value></param>
<param><key>interp</key><value>interp_2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0_0</value></param>
<param><key>decim</key><value>audio_rate_in</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>audio_rate_out</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0_0_0</value></param>
<param><key>decim</key><value>audio_rate_in</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>audio_rate_out</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>decim</key><value>decim_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>interp_1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2_0</value></param>
<param><key>decim</key><value>decim_2</value></param>
<param><key>interp</key><value>interp_2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_0</value></param>
<param><key>filename</key><value>/captures/wwv/WWV_NS_2021-05-31T05:30:00Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_1</value></param>
<param><key>filename</key><value>/captures/wwv/WWV_EW_2021-05-31T05:30:00Z.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>WWV</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>ns_ant</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>lhcp</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>rhcp</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>x_corr</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>ew_ant</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_6</value></param>
<param><key>stream_id</key><value>ns_filt</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_7</value></param>
<param><key>stream_id</key><value>ew_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>ns_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>rhcp</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ew_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>rhcp</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ns_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ns_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ns_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ew_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>lhcp</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>lhcp</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_1</value></param>
<param><key>stream_id</key><value>ew_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ew_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>ns_ant</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>x_corr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>ew_ant</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>stream_id</key><value>ew_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_6</value></param>
<param><key>stream_id</key><value>ns_filt</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>virtual_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>virtual_sink_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_1</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_1</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>fft_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_0_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_1</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0_1</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_1</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_1_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_2</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>virtual_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>virtual_sink_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_3</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>blocks_multiply_matrix_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>rational_resampler_xxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_6</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_6</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
