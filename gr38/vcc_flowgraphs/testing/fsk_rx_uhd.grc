options:
  parameters:
    author: Zach Leffke, KJ4QLP
    category: '[VCC Hier Blocks]'
    description: GMSK AX.25 Receiver
    generate_options: qt_gui
    id: fsk_rx_hier
    output_language: python
    title: VCC FSK Receiver
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decim
  id: variable
  parameters:
    value: 25*5
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '24'
  states: {}
- name: lpf_cutoff
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: lpf_trans
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: rx_correct
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,4
    orient: Qt.Horizontal
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '-300'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,4
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '86'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: (samp_rate/decim*interp)/baud
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: automatic gain control
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      FSK/GMSK
      demodulator
    gain: (samp_rate/decim*interp)/(2*math.pi*fsk_dev/8.0)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /captures/fsk_rx_uhd_250k.fc32
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0_2_0
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Output is KISS Frame
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    host: 0.0.0.0
    mtu: '1024'
    port: '8001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: soft bits to hard bits
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Timing Recovery
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.25'
    omega: samps_per_symb*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      G3RUH Polynomial
      1+x^12+x^17
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: narrow signal filter
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim *interp
    type: fir_filter_ccf
    width: lpf_trans
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enable to Record RAW IQ
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim*interp
    comment: |-
      in0 = Pre-detection Spectrum
      in1 = Spectrum after AGC and filtering
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,4,4
    label2: ''
    legend: 'False'
    name: '"RX Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-150'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: decim
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 401.5e6
  states: {}
- name: rx_offset
  id: parameter
  parameters:
    type: eng_float
    value: 125e3
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_pdu_to_kiss_0
  id: satellites_pdu_to_kiss
  parameters:
    control_byte: 'True'
    include_timestamp: 'False'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(rx_freq+rx_correct, rx_offset)
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: soft_bits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pre-d
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: agc_filt
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: soft_bits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pre-d
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: agc_filt
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0_0, '0']
- [digital_descrambler_bb_0, '0', satellites_nrzi_decode_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_1, '0']
- [low_pass_filter_0, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_0_0, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', virtual_sink_1, '0']
- [satellites_hdlc_deframer_0, out, satellites_pdu_to_kiss_0, in]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [satellites_pdu_to_kiss_0, out, blocks_socket_pdu_0_2_0, pdus]
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_1_0, '1']

metadata:
  file_format: 1
