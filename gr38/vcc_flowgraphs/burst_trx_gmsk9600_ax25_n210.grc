options:
  parameters:
    author: Zach Leffke, KJ4QLP
    description: VCC Burst TX/RX, 9600 Baud GMSK, AX.25
    generate_options: qt_gui
    id: burst_trx_gmsk9600_ax25_n210
    output_language: python
    title: VCC Burst TX/RX, 9600 Baud GMSK, AX.25, w/ PTT
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:2,2,1,1
    label: BB Gain
    type: real
    value: '.75'
  states: {}
- name: ceres_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@1:3,4,1,2
    label: Ceres Offset
    type: real
    value: 40e3
  states: {}
- name: chan_filt_cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: chan_filt_trans
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/2000)
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: fn
  id: variable
  parameters:
    value: '"VCC_{:s}_{:s}".format(gs_id, ts_str)'
  states: {}
- name: fp
  id: variable
  parameters:
    value: '"/vtgs/captures/vcc/{:s}".format(fn)'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: gs_id
  id: variable
  parameters:
    value: '"VTGS"'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '48'
  states: {}
- name: interp_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: man_tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:3,0,1,1
    label: TX Freq Offset
    type: real
    value: '0.0'
  states: {}
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:4,0,1,2
    label: RX Freq
    type: real
    value: 401.08e6
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:4,2,1,2
    label: RX Gain
    type: real
    value: '20'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: samp_rate/2.0
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: float(250e3)
  states: {}
- name: trigger_thresh
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@1:4,4,1,2
    label: Trigger Thresh
    type: real
    value: '-2'
  states: {}
- name: ts_str
  id: variable
  parameters:
    value: dt.strftime(dt.utcnow(), "%Y%m%d_%H%M%S" )
  states: {}
- name: tx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:2,0,1,1
    label: TX Freq
    type: real
    value: 401.12e6
  states: {}
- name: tx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@2:2,3,1,1
    label: TX Gain
    type: real
    value: '10'
  states: {}
- name: tx_offset
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: tx_sel
  id: variable
  parameters:
    value: '[tx_tune, -1*man_tune]'
  states: {}
- name: tx_tune
  id: variable
  parameters:
    value: tx_freq - uplink_freq
  states: {}
- name: tx_tune_sel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: main_tab@2:3,1,1,1
    label: TX Tune Mode
    label0: Auto
    label1: Manual
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: uplink_freq
  id: variable
  parameters:
    value: tx_freq
  states: {}
- name: uplink_offset
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@2:2,1,1,1
    type: real
    value: '-1* tx_tune'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '10'
    comment: automatic gain control
    decay_rate: '1e-1'
    gain: '1'
    max_gain: '65536'
    reference: '65536'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1 * tx_sel[tx_tune_sel]'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: VT Freq Offset
    freq: '-1 * ceres_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: Center VCC-Ceres
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    comment: RF Front End Daemon
    host: 0.0.0.0
    mtu: '1024'
    port: '8001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_2
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Expects KISS Frames on input
      Sends KISS Frames on output
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    host: 10.42.0.21
    mtu: '1024'
    port: '8000'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: burst_rx_es_hier_0
  id: burst_rx_es_hier
  parameters:
    avg_len: '100'
    baud: '9600'
    samp_rate: samp_rate/decim*interp
    samps_per_symb: '10'
    trigger_thresh: trigger_thresh
  states: {}
- name: fsk_burst_detector_0
  id: fsk_burst_detector
  parameters:
    avg_len: '100.0'
    cons_offset: '3'
    decim: decim
    fsk_dev: fsk_dev
    interp: interp
    samp_rate: samp_rate
  states: {}
- name: gmsk_ax25_rx_hier_0
  id: gmsk_ax25_rx_hier
  parameters:
    lpf_cutoff: 7.2e3
    lpf_trans: 1e3
    quad_demod_gain: (samp_rate/decim*interp/decim_2*interp_2)/(2*math.pi*fsk_dev/8.0)
    samp_rate: '48000'
    samps_per_symb: '5'
  states: {}
- name: gmsk_tx_burst_hier2_0
  id: gmsk_tx_burst_hier2
  parameters:
    bb_gain: bb_gain
    bt: '.5'
    delay_enable: '1'
    pad_front: '0'
    pad_tail: '0'
    ptt_delay: '.25'
    samp_rate: samp_rate
  states: {}
- name: gpredict_MsgPairToVar_1
  id: gpredict_MsgPairToVar
  parameters:
    target: uplink_freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '7356'
    verbose: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string; import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Channel Filter
      Wide enough for doppler spread
    cutoff_freq: chan_filt_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim *interp
    type: fir_filter_ccf
    width: chan_filt_trans
    win: firdes.WIN_HAMMING
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,2,8
    label0: Full Band
    label1: RX Channel
    label2: TX Channel
    num_tabs: '3'
  states: {}
- name: pyqt_ctime_plot_0
  id: pyqt_ctime_plot
  parameters:
    gui_hint: main_tab@1:2,4,1,4
    l: ''
  states: {}
- name: pyqt_meta_text_output_0
  id: pyqt_meta_text_output
  parameters:
    gui_hint: main_tab@1:3,6,4,2
  states: {}
- name: pyqt_text_output_0
  id: pyqt_text_output
  parameters:
    comment: rffe daemon feedback
    gui_hint: main_tab@2:4,0,1,4
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*interp/decim*interp_2/decim_2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,4,2,4
    label1: '''orig'''
    label2: '''corr'''
    name: '"Burst RX Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim*interp / decim_2 * interp_2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:0,0,2,4
    label1: pre-d
    legend: 'False'
    name: '"Ceres Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '50'
    ymin: '-50'
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim*interp/2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@2:0,2,2,2
    legend: 'False'
    name: '"TX Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:0,0,1,8
    label1: pre-d
    legend: 'False'
    name: '"VCC RX Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-150'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@0:1,0,1,8
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim*interp / decim_2 * interp_2
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: main_tab@1:2,0,2,4
    int_max: '50'
    int_min: '-50'
    showports: 'True'
    type: complex
    update_time: '0.0010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 125k sample rate
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: bypassed}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 96k sample rate
    decim: decim
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: decim_2
    interp: interp_2
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_4
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp/2
    taps: ''
    type: ccc
  states: {}
- name: rffe_ctl_tag_ptt_pdu_0
  id: rffe_ctl_tag_ptt_pdu
  parameters:
    comment: PTT Trigger to RFFE Daemon
    eob_key: '"tx_eob"'
    ptt_mode: '"TX"'
    samp_rate: samp_rate
    sob_key: '"tx_sob"'
    tx_time_key: '"tx_time"'
  states: {}
- name: sigmf_sink_0
  id: sigmf_sink
  parameters:
    append: 'False'
    author: Zach Leffke
    description: VCC TM/TC v1.0.0, GMSK9600, AX.25, w/ PTT
    field_10_key: ''
    field_10_type: string
    field_10_value: ''
    field_11_key: ''
    field_11_type: string
    field_11_value: ''
    field_12_key: ''
    field_12_type: string
    field_12_value: ''
    field_13_key: ''
    field_13_type: string
    field_13_value: ''
    field_14_key: ''
    field_14_type: string
    field_14_value: ''
    field_15_key: ''
    field_15_type: string
    field_15_value: ''
    field_16_key: ''
    field_16_type: string
    field_16_value: ''
    field_17_key: ''
    field_17_type: string
    field_17_value: ''
    field_18_key: ''
    field_18_type: string
    field_18_value: ''
    field_19_key: ''
    field_19_type: string
    field_19_value: ''
    field_1_key: ''
    field_1_type: float
    field_1_value: '0'
    field_20_key: ''
    field_20_type: string
    field_20_value: ''
    field_21_key: ''
    field_21_type: string
    field_21_value: ''
    field_22_key: ''
    field_22_type: string
    field_22_value: ''
    field_23_key: ''
    field_23_type: string
    field_23_value: ''
    field_24_key: ''
    field_24_type: string
    field_24_value: ''
    field_25_key: ''
    field_25_type: string
    field_25_value: ''
    field_2_key: ''
    field_2_type: string
    field_2_value: ''
    field_3_key: ''
    field_3_type: string
    field_3_value: ''
    field_4_key: ''
    field_4_type: string
    field_4_value: ''
    field_5_key: ''
    field_5_type: string
    field_5_value: ''
    field_6_key: ''
    field_6_type: string
    field_6_value: ''
    field_7_key: ''
    field_7_type: string
    field_7_value: ''
    field_8_key: ''
    field_8_type: string
    field_8_value: ''
    field_9_key: ''
    field_9_type: string
    field_9_value: ''
    filename: fp
    hardware: 2X M2 400CP30, ARR Preamp, N210 w/ UBX
    license: MIT
    num_extra_fields: '0'
    samp_rate: samp_rate
    time_mode: gr_sigmf.sigmf_time_mode_absolute
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(tx_freq, tx_offset)
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: '"addr=192.168.10.6"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(rx_freq, rx_offset)
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: 'True'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: vcc_qt_hex_text_tx
  id: vcc_qt_hex_text
  parameters:
    comment: tx ax.25 frames
    gui_hint: main_tab@2:0,0,2,2
  states: {}
- name: vcc_qt_hex_text_tx_0
  id: vcc_qt_hex_text
  parameters:
    comment: rx ax.25 frames
    gui_hint: main_tab@1:5,0,2,6
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: agc_filt
  states: {}
- name: virtual_sink_rx_kiss
  id: virtual_sink
  parameters:
    stream_id: rx_kiss
  states: {}
- name: virtual_sink_tx_kiss
  id: virtual_sink
  parameters:
    stream_id: tx_kiss
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: agc_filt
  states: {}
- name: virtual_source_rx_kiss
  id: virtual_source
  parameters:
    stream_id: rx_kiss
  states: {}
- name: virtual_source_tx_kiss
  id: virtual_source
  parameters:
    stream_id: tx_kiss
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_4, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_socket_pdu_0, pdus, pyqt_text_output_0, pdus]
- [blocks_socket_pdu_0_2, pdus, virtual_sink_tx_kiss, '0']
- [burst_rx_es_hier_0, '0', rational_resampler_xxx_3, '0']
- [burst_rx_es_hier_0, '1', rational_resampler_xxx_2, '0']
- [burst_rx_es_hier_0, brst_corr, pyqt_ctime_plot_0, cpdus]
- [burst_rx_es_hier_0, meta, pyqt_meta_text_output_0, pdus]
- [fsk_burst_detector_0, '0', burst_rx_es_hier_0, '0']
- [gmsk_ax25_rx_hier_0, '0', qtgui_freq_sink_x_1, '1']
- [gmsk_ax25_rx_hier_0, kiss, vcc_qt_hex_text_tx_0, pdus]
- [gmsk_ax25_rx_hier_0, kiss, virtual_sink_rx_kiss, '0']
- [gmsk_tx_burst_hier2_0, '0', blocks_multiply_xx_0, '0']
- [gmsk_tx_burst_hier2_0, '0', rffe_ctl_tag_ptt_pdu_0, '0']
- [gmsk_tx_burst_hier2_0, ax25, vcc_qt_hex_text_tx, pdus]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_1, inpair]
- [low_pass_filter_0, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_1_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_3, '0', gmsk_ax25_rx_hier_0, '0']
- [rational_resampler_xxx_4, '0', qtgui_freq_sink_x_1_0_0, '0']
- [rffe_ctl_tag_ptt_pdu_0, ptt, blocks_socket_pdu_0, pdus]
- [uhd_usrp_source_1, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_1, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_1, '0', sigmf_sink_0, '0']
- [virtual_source_1_0, '0', burst_rx_es_hier_0, '1']
- [virtual_source_1_0, '0', fsk_burst_detector_0, '0']
- [virtual_source_1_0, '0', rational_resampler_xxx_1_0, '0']
- [virtual_source_rx_kiss, '0', blocks_socket_pdu_0_2, pdus]
- [virtual_source_tx_kiss, '0', gmsk_tx_burst_hier2_0, kiss/ax25]

metadata:
  file_format: 1
