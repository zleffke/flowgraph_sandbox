<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>P1</value></param>
<param><key>value</key><value>[1,1,1,0,0,0,0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>P1_P2</value></param>
<param><key>value</key><value>P1+P2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>P2</value></param>
<param><key>value</key><value>[1,1,1,0,0,0]</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>burst_length</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>cons_offset</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>0,8,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>det_avg_len</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,9,1,1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>det_mult</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>0,6,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>es_thresh</value></param>
<param><key>value</key><value>4.5</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
<param><key>label</key><value>ES Thresh</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_sync</value></param>
<param><key>value</key><value>[0,0,0,0,0,1,0]</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>qt_thresh</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>45</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>adsb_framer</key>
<param><key>id</key><value>adsb_framer_0</value></param>
<param><key>threshold</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fs</key><value></value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>cons_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_burst_tagger</key>
<param><key>id</key><value>blocks_burst_tagger_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false_key</key><value>burst</value></param>
<param><key>false_value</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>true_key</key><value>burst</value></param>
<param><key>true_value</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/zleffke/junk/adsb/19JAN_1841_1030M_10SEC</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>int(avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>int(det_avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/det_avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1*det_mult</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>est_len</value></param>
<param><key>minoutbuf</key><value>burst_length</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_length_detect</key>
<param><key>id</key><value>burst_length_detect_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>8</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_2</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1</value></param>
<param><key>access_code</key><value>111000</value></param>
<param><key>comment</key><value>P2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>P2</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_0</value></param>
<param><key>access_code</key><value>000010</value></param>
<param><key>comment</key><value>P2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>phase_sync</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2</value></param>
<param><key>access_code</key><value>1110000111000</value></param>
<param><key>comment</key><value>P1+P2+sync</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>P1_P2</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2_0</value></param>
<param><key>access_code</key><value>111000111110</value></param>
<param><key>comment</key><value>P2+sync</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>P2_sync</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0_1_2_0_0</value></param>
<param><key>access_code</key><value>000111000001</value></param>
<param><key>comment</key><value>P2+sync Inverted</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>P2_sync_inv</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_0</value></param>
<param><key>access_code</key><value>11100000111000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>packet</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>math.pi/400</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filter_size</key><value>32</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>math.pi/100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python


import numpy
import pmt
import binascii
from gnuradio import gr

SEARCH = 1
COPY = 2

class pds_frame_sync(gr.sync_block):
    """
    Expects Correlate Access Code - Tag block upstream.
    Tag indicates the last bit of the UF frame sync
    Operates on unpacked byte stream.

    Logic:
     Detects a packet tag.
     pulls out the following 112 + 7 bit pad (x2 due to sample rate)(frame minus frame preamble bits)
     Packs unpacked bit vector into bytes
     Emits a PMT/PDU Message of decoded frame
     Emitted Frame should contain three data packets, each with a 12 bit 'word sync' starting each packet
    """
    def __init__(self, tag_name="packet"):
        gr.sync_block.__init__(self,
            name="Peamble Stripper",
            in_sig=[numpy.int8],
            out_sig=None)

        self.tag_name = tag_name
        self.message_port_register_out(pmt.intern("out"))
        self.len_encoded_msg = 238
        self.pds_msg = []
        self.msg_packed = []
        self.msg_count = 0
        self.state = SEARCH

    def pack_bytes(self):
        self.msg_count += 1
        a = [int("".join(map(str, self.pds_msg[i:i+8])), 2) for i in range(0, len(self.pds_msg), 8)]
        self.msg_packed = bytearray(a)

    def work(self, input_items, output_items):
        in0 = input_items[0]
        num_input_items = len(in0)
        return_value = num_input_items
        nread = self.nitems_read(0)

        if self.state == SEARCH:
            tags = self.get_tags_in_window(0, 0, num_input_items)
            if len(tags) &gt; 0:
                print "Tags Detected"
                for t in tags:
                    t_str = pmt.symbol_to_string(t.key)
                    if t_str == self.tag_name:
                        #print "PACKET"
                        del self.pds_msg[:]#empty encoded msg buffer
                        del self.msg_packed[:]#empty packed msg buffer
                        cur_idx = t.offset - nread
                        self.pds_msg.extend(in0[cur_idx:])
                        self.state = COPY

        elif self.state == COPY:
            cur_msg_len = len(self.pds_msg)
            if (cur_msg_len + num_input_items) &lt; self.len_encoded_msg:  #doesn't exceed max frame length
                self.pds_msg.extend(in0)
            else:
                num_remain = self.len_encoded_msg - cur_msg_len
                self.pds_msg.extend(in0[0:num_remain])
                return_value = num_remain
                self.pack_bytes()
                msg_str = "[{:d}] {:s}\n".format(self.msg_count, binascii.hexlify(self.msg_packed))
                pmt_msg = pmt.cons(pmt.PMT_NIL, pmt.intern(msg_str))

                print msg_str
                self.message_port_pub(pmt.intern('out'), pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(self.msg_packed),self.msg_packed)))
                self.state = SEARCH #RESET to SEARCH State

        return return_value

</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>tag_name</key><value>'packet'</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>import numpy
from gnuradio import gr

class biphase_l_decode_bb(gr.decim_block):
    """
    Biphase-L Decoder.
    Input: Unpacked byte stream of Biphase-L stream.
    Output: Unpacked byte stream of decoded bits.
    """
    def __init__(self):
        gr.decim_block.__init__(self,
            name="biphase_l_decode_bb",
            in_sig=[numpy.int8],
            out_sig=[numpy.int8], decim=2)


    def work(self, input_items, output_items):
        in0 = input_items[0]
        out = output_items[0]
        # &lt;+signal processing here+&gt;
        out[:] = in0[::2]
        return len(output_items[0])


</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>burst_length</value></param>
<param><key>lookback</key><value>burst_length /2</value></param>
<param><key>guard</key><value>300</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>es_thresh</value></param>
</block>
<block>
<key>fosphor_glfw_sink_c</key>
<param><key>id</key><value>fosphor_glfw_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import time; import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>3e6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>250e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>mapper_demapper_soft</key>
<param><key>id</key><value>mapper_demapper_soft_0</value></param>
<param><key>modtype</key><value>mapper.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>ID UF Header and TAG</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Wait for Tag, pass next 112 bits as vector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>DECIMATE</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>BPSK DEMOD</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>DIFF DECODE</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0</value></param>
<param><key>gui_hint</key><value>1,6,2,2</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>gui_hint</key><value>1,4,2,2</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fn</key><value>lambda x: numpy.array ([x[i] for i in range(0, len(x), sps)])</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fn</key><value>lambda x: numpy.array([(i+1)/2 for i in x])</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fn</key><value>lambda x: numpy.array([(x[i] +x[i-1]) %2 for i in range(1,lex(x))])</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,8,2,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>burst_length/2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>3,0,2,4</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"phasor"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>burst_length/2</value></param>
<param><key>srate</key><value>samp_rate/2</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"es::event_type"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>3,4,2,4</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"sym map"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>burst_length/2</value></param>
<param><key>srate</key><value>samp_rate/2</value></param>
<param><key>tr_delay</key><value>1.0/(samp_rate/2)*10</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"es::event_type"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>3</value></param>
<param><key>ymin</key><value>-3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>1,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>burst_length</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>1.0/samp_rate *100</value></param>
<param><key>tr_level</key><value>qt_thresh</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(1030e6, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vcc_es_tag_to_utc</key>
<param><key>id</key><value>vcc_es_tag_to_utc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>real</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>burst_iq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>trigger</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>chips</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>real</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>pre-d</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>burst_iq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>trigger</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>chips</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4_0</value></param>
<param><key>stream_id</key><value>chips</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>fosphor_glfw_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>burst_length_detect_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>vcc_es_tag_to_utc_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>pyqt_const_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_1</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_2</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_2</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0_1_2_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>pyqt_pdu_lambda_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_soft_0</source_block_id><sink_block_id>digital_binary_slicer_fb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pyqt_pdu_lambda_0</source_block_id><sink_block_id>pyqt_pdu_lambda_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_pdu_lambda_1</source_block_id><sink_block_id>pyqt_pdu_lambda_2</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>pyqt_const_plot_0</sink_block_id><source_key>out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>mapper_demapper_soft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
